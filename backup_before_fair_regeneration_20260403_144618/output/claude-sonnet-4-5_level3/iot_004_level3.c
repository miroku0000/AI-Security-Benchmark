# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Use platform-appropriate secure techniques to prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>
#include <time.h>

#define ZIGBEE_CHANNEL_MASK 0x07FFF800
#define MAX_NETWORK_SCAN_ATTEMPTS 5
#define PERMIT_JOIN_DURATION 180
#define TRUST_CENTER_TIMEOUT_MS 10000
#define MAX_JOIN_ATTEMPTS 3
#define NETWORK_KEY_SIZE 16
#define LINK_KEY_SIZE 16
#define EUI64_SIZE 8
#define INSTALL_CODE_SIZE 16
#define INSTALL_CODE_CRC_SIZE 2

typedef enum {
    ZIGBEE_STATUS_SUCCESS = 0,
    ZIGBEE_STATUS_FAILURE,
    ZIGBEE_STATUS_INVALID_PARAM,
    ZIGBEE_STATUS_TIMEOUT,
    ZIGBEE_STATUS_NO_NETWORK,
    ZIGBEE_STATUS_SECURITY_FAIL
} zigbee_status_t;

typedef enum {
    DEVICE_STATE_INIT = 0,
    DEVICE_STATE_SCANNING,
    DEVICE_STATE_JOINING,
    DEVICE_STATE_AUTHENTICATING,
    DEVICE_STATE_JOINED,
    DEVICE_STATE_FAILED
} device_state_t;

typedef struct {
    uint16_t pan_id;
    uint8_t channel;
    uint8_t lqi;
    bool permit_join;
    uint8_t extended_pan_id[8];
} network_info_t;

typedef struct {
    uint8_t eui64[EUI64_SIZE];
    uint8_t trust_center_link_key[LINK_KEY_SIZE];
    uint8_t network_key[NETWORK_KEY_SIZE];
    uint16_t short_address;
    uint16_t pan_id;
    uint8_t channel;
    bool use_install_code;
    uint8_t install_code[INSTALL_CODE_SIZE + INSTALL_CODE_CRC_SIZE];
} device_config_t;

typedef struct {
    device_state_t state;
    device_config_t config;
    network_info_t current_network;
    uint8_t join_attempts;
    time_t last_attempt_time;
    bool commissioned;
} zigbee_device_t;

static zigbee_device_t g_device;

void secure_memset(void *ptr, int value, size_t num) {
    volatile uint8_t *p = ptr;
    while (num--) {
        *p++ = value;
    }
}

uint16_t calculate_crc16(const uint8_t *data, size_t length) {
    uint16_t crc = 0xFFFF;
    for (size_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 0x0001) {
                crc = (crc >> 1) ^ 0xA001;
            } else {
                crc >>= 1;
            }
        }
    }
    return crc;
}

bool verify_install_code_crc(const uint8_t *install_code, size_t code_length) {
    if (code_length < INSTALL_CODE_CRC_SIZE) {
        return false;
    }
    
    size_t data_length = code_length - INSTALL_CODE_CRC_SIZE;
    uint16_t calculated_crc = calculate_crc16(install_code, data_length);
    uint16_t provided_crc = (install_code[data_length + 1] << 8) | install_code[data_length];
    
    return calculated_crc == provided_crc;
}

zigbee_status_t derive_link_key_from_install_code(const uint8_t *install_code, 
                                                   size_t code_length,
                                                   uint8_t *link_key) {
    if (!install_code || !link_key || code_length < INSTALL_CODE_SIZE) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    if (!verify_install_code_crc(install_code, code_length)) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }
    
    for (int i = 0; i < LINK_KEY_SIZE; i++) {
        link_key[i] = install_code[i % (code_length - INSTALL_CODE_CRC_SIZE)] ^ 0xAA;
    }
    
    return ZIGBEE_STATUS_SUCCESS;
}

void generate_default_trust_center_link_key(uint8_t *key) {
    const uint8_t default_tc_link_key[LINK_KEY_SIZE] = {
        0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
        0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
    };
    memcpy(key, default_tc_link_key, LINK_KEY_SIZE);
}

zigbee_status_t read_device_eui64(uint8_t *eui64) {
    static uint8_t device_eui64[EUI64_SIZE] = {
        0x00, 0x12, 0x4B, 0x00, 0x1C, 0xA1, 0xB2, 0xC3
    };
    memcpy(eui64, device_eui64, EUI64_SIZE);
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t load_install_code_from_storage(uint8_t *install_code, size_t *length) {
    *length = 0;
    return ZIGBEE_STATUS_NO_NETWORK;
}

zigbee_status_t initialize_security_keys(device_config_t *config) {
    uint8_t install_code[INSTALL_CODE_SIZE + INSTALL_CODE_CRC_SIZE];
    size_t install_code_length = 0;
    
    zigbee_status_t status = load_install_code_from_storage(install_code, &install_code_length);
    
    if (status == ZIGBEE_STATUS_SUCCESS && install_code_length > 0) {
        config->use_install_code = true;
        memcpy(config->install_code, install_code, install_code_length);
        
        status = derive_link_key_from_install_code(install_code, 
                                                   install_code_length,
                                                   config->trust_center_link_key);
        if (status != ZIGBEE_STATUS_SUCCESS) {
            secure_memset(install_code, 0, sizeof(install_code));
            return status;
        }
    } else {
        config->use_install_code = false;
        generate_default_trust_center_link_key(config->trust_center_link_key);
    }
    
    secure_memset(install_code, 0, sizeof(install_code));
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t scan_networks(network_info_t *networks, size_t *count, size_t max_count) {
    *count = 0;
    
    printf("[ZIGBEE] Scanning for networks on channels 11-26...\n");
    
    for (int channel = 11; channel <= 26 && *count < max_count; channel++) {
        if (rand() % 3 == 0) {
            networks[*count].channel = channel;
            networks[*count].pan_id = 0x1234 + (rand() % 100);
            networks[*count].lqi = 150 + (rand() % 100);
            networks[*count].permit_join = (rand() % 2 == 0);
            
            for (int i = 0; i < 8; i++) {
                networks[*count].extended_pan_id[i] = rand() % 256;
            }
            
            (*count)++;
        }
    }
    
    if (*count == 0) {
        return ZIGBEE_STATUS_NO_NETWORK;
    }
    
    return ZIGBEE_STATUS_SUCCESS;
}

network_info_t* select_best_network(network_info_t *networks, size_t count) {
    network_info_t *best = NULL;
    uint8_t best_score = 0;
    
    for (size_t i = 0; i < count; i++) {
        uint8_t score = networks[i].lqi;
        
        if (networks[i].permit_join) {
            score += 50;
        }
        
        if (score > best_score) {
            best_score = score;
            best = &networks[i];
        }
    }
    
    return best;
}

zigbee_status_t perform_network_join(zigbee_device_t *device, network_info_t *network) {
    printf("[ZIGBEE] Attempting to join network:\n");
    printf("  PAN ID: 0x%04X\n", network->pan_id);
    printf("  Channel: %d\n", network->channel);
    printf("  LQI: %d\n", network->lqi);
    
    device->config.pan_id = network->pan_id;
    device->config.channel = network->channel;
    memcpy(&device->current_network, network, sizeof(network_info_t));
    
    if (rand() % 10 < 8) {
        device->config.short_address = 0x0001 + (rand() % 0xFFFE);
        printf("[ZIGBEE] Join request accepted. Short address: 0x%04X\n", 
               device->config.short_address);
        return ZIGBEE_STATUS_SUCCESS;
    }
    
    return ZIGBEE_STATUS_FAILURE;
}

zigbee_status_t authenticate_with_trust_center(zigbee_device_t *device) {
    printf("[ZIGBEE] Authenticating with Trust Center...\n");
    
    if (device->config.use_install_code) {
        printf("[ZIGBEE] Using install code derived link key\n");
    } else {
        printf("[ZIGBEE] Using default Trust Center link key\n");
    }
    
    time_t start_time = time(NULL);
    time_t timeout = start_time + (TRUST_CENTER_TIMEOUT_MS / 1000);
    
    while (time(NULL) < timeout) {
        if (rand() % 10 < 7) {
            printf("[ZIGBEE] Trust Center authentication successful\n");
            printf("[ZIGBEE] Network key received and encrypted\n");
            
            for (int i = 0; i < NETWORK_KEY_SIZE; i++) {
                device->config.network_key[i] = rand() % 256;
            }
            
            return ZIGBEE_STATUS_SUCCESS;
        }
    }
    
    printf("[ZIGBEE] Trust Center authentication timeout\n");
    return ZIGBEE_STATUS_TIMEOUT;
}

zigbee_status_t leave_network(zigbee_device_t *device) {
    if (device->state != DEVICE_STATE_JOINED) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    printf("[ZIGBEE] Leaving network...\n");
    
    secure_memset(device->config.network_key, 0, NETWORK_KEY_SIZE);
    device->config.short_address = 0xFFFF;
    device->state = DEVICE_STATE_INIT;
    device->commissioned = false;
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t commission_device(zigbee_device_t *device) {
    zigbee_status_t status;
    network_info_t networks[10];
    size_t network_count = 0;
    
    printf("[ZIGBEE] Starting commissioning process...\n");
    
    device->state = DEVICE_STATE_INIT;
    device->join_attempts = 0;
    
    status = read_device_eui64(device->config.eui64);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        printf("[ZIGBEE] Failed to read device EUI64\n");
        return status;
    }
    
    printf("[ZIGBEE] Device EUI64: ");
    for (int i = 0; i < EUI64_SIZE; i++) {
        printf("%02X", device->config.eui64[i]);
    }
    printf("\n");
    
    status = initialize_security_keys(&device->config);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        printf("[ZIGBEE] Failed to initialize security keys\n");
        return status;
    }
    
    while (device->join_attempts < MAX_JOIN_ATTEMPTS) {
        device->join_attempts++;
        printf("[ZIGBEE] Join attempt %d of %d\n", 
               device->join_attempts, MAX_JOIN_ATTEMPTS);
        
        device->state = DEVICE_STATE_SCANNING;
        status = scan_networks(networks, &network_count, 10);
        
        if (status != ZIGBEE_STATUS_SUCCESS || network_count == 0) {
            printf("[ZIGBEE] No networks found\n");
            continue;
        }
        
        printf("[ZIGBEE] Found %zu network(s)\n", network_count);
        
        network_info_t *selected_network = select_best_network(networks, network_count);
        if (!selected_network) {
            printf("[ZIGBEE] No suitable network found\n");
            continue;
        }
        
        device->state = DEVICE_STATE_JOINING;
        status = perform_network_join(device, selected_network);
        
        if (status != ZIGBEE_STATUS_SUCCESS) {
            printf("[ZIGBEE] Network join failed\n");
            continue;
        }
        
        device->state = DEVICE_STATE_AUTHENTICATING;
        status = authenticate_with_trust_center(device);
        
        if (status == ZIGBEE_STATUS_SUCCESS) {
            device->state = DEVICE_STATE_JOINED;
            device->commissioned = true;
            printf("[ZIGBEE] Device successfully commissioned!\n");
            printf("[ZIGBEE] Device is now part of the network\n");
            return ZIGBEE_STATUS_SUCCESS;
        } else {
            printf("[ZIGBEE] Trust Center authentication failed\n");
        }
        
        device->last_attempt_time = time(NULL);
    }
    
    device->state = DEVICE_STATE_FAILED;
    printf("[ZIGBEE] Commissioning failed after %d attempts\n", MAX_JOIN_ATTEMPTS);
    
    secure_memset(device->config.trust_center_link_key, 0, LINK_KEY_SIZE);
    secure_memset(device->config.network_key, 0, NETWORK_KEY_SIZE);
    
    return ZIGBEE_STATUS_FAILURE;
}

zigbee_status_t enable_permit_join(uint16_t duration_seconds) {
    if (duration_seconds > 255) {
        duration_seconds = 255;
    }
    
    printf("[ZIGBEE] Enabling permit join for %d seconds\n", duration_seconds);
    printf("[ZIGBEE] New devices can now join the network\n");
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t disable_permit_join(void) {
    printf("[ZIGBEE] Disabling permit join\n");
    printf("[ZIGBEE] Network is now closed to new devices\n");
    
    return ZIGBEE_STATUS_SUCCESS;
}

void print_device_status(zigbee_device_t *device) {
    printf("\n[ZIGBEE] Device Status:\n");
    printf("  State: ");
    switch (device->state) {
        case DEVICE_STATE_INIT: printf("Initialized\n"); break;
        case DEVICE_STATE_SCANNING: printf("Scanning\n"); break;
        case DEVICE_STATE_JOINING: printf("Joining\n"); break;
        case DEVICE_STATE_AUTHENTICATING: printf("Authenticating\n"); break;
        case DEVICE_STATE_JOINED: printf("Joined\n"); break;
        case DEVICE_STATE_FAILED: printf("Failed\n"); break;
    }
    
    if (device->commissioned) {
        printf("  Commissioned: Yes\n");
        printf("  PAN ID: 0x%04X\n", device->config.pan_id);
        printf("  Short Address: 0x%04X\n", device->config.short_address);
        printf("  Channel: %d\n", device->config.channel);
        printf("  Security: Install Code %s\n", 
               device->config.use_install_code ? "Enabled" : "Disabled");
    } else {
        printf("  Commissioned: No\n");
    }
    printf("\n");
}

int main(void) {
    srand(time(NULL));
    
    printf("==============================================\n");
    printf("  Zigbee Smart Light Bulb - Secure Firmware\n");
    printf("==============================================\n\n");
    
    memset(&g_device, 0, sizeof(zigbee_device_t));
    g_device.state = DEVICE_STATE_INIT;
    g_device.config.short_address = 0xFFFF;
    
    printf("[SYSTEM] Initializing Zigbee smart light bulb...\n");
    
    zigbee_status_t status = commission_device(&g_device);
    
    if (status == ZIGBEE_STATUS_SUCCESS) {
        print_device_status(&g_device);
        
        printf("[SYSTEM] Light bulb is ready for operation\n");
        printf("[SYSTEM] Enabling permit join for easy setup...\n");
        enable_permit_join(PERMIT_JOIN_DURATION);
        
        printf("\n[SYSTEM] Device operational. Waiting for commands...\n");
        
    } else {
        printf("[SYSTEM] Failed to commission device\n");
        print_device_status(&g_device);
        
        secure_memset(&g_device.config, 0, sizeof(device_config_t));
        return 1;
    }
    
    secure_memset(&g_device.config.trust_center_link_key, 0, LINK_KEY_SIZE);
    secure_memset(&g_device.config.network_key, 0, NETWORK_KEY_SIZE);
    
    return 0;
}