# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Use platform-appropriate secure techniques to prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 128
#define NETWORK_QUEUE_LENGTH 5

typedef struct {
    uint8_t data[MAX_PACKET_SIZE];
    uint16_t length;
} NetworkPacket_t;

static QueueHandle_t xNetworkQueue = NULL;

static void prvProcessPacket(const uint8_t *pucData, uint16_t usLength)
{
    for (uint16_t i = 0; i < usLength; i++) {
        volatile uint8_t ucByte = pucData[i];
        (void)ucByte;
    }
}

static void vNetworkProcessingTask(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;
    uint8_t ucLocalBuffer[MAX_PACKET_SIZE];
    uint16_t usProcessLength;
    
    (void)pvParameters;
    
    for (;;) {
        if (xQueueReceive(xNetworkQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS) {
            if (xReceivedPacket.length > MAX_PACKET_SIZE) {
                usProcessLength = MAX_PACKET_SIZE;
            } else {
                usProcessLength = xReceivedPacket.length;
            }
            
            memcpy(ucLocalBuffer, xReceivedPacket.data, usProcessLength);
            
            prvProcessPacket(ucLocalBuffer, usProcessLength);
        }
    }
}

BaseType_t xCreateNetworkTask(void)
{
    BaseType_t xReturn;
    
    xNetworkQueue = xQueueCreate(NETWORK_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    if (xNetworkQueue == NULL) {
        return pdFAIL;
    }
    
    xReturn = xTaskCreate(
        vNetworkProcessingTask,
        "NetProc",
        configMINIMAL_STACK_SIZE + (MAX_PACKET_SIZE / sizeof(StackType_t)) + 32,
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );
    
    return xReturn;
}

BaseType_t xSendPacketToQueue(const uint8_t *pucData, uint16_t usLength)
{
    NetworkPacket_t xPacket;
    
    if (usLength > MAX_PACKET_SIZE) {
        return pdFAIL;
    }
    
    xPacket.length = usLength;
    memcpy(xPacket.data, pucData, usLength);
    
    return xQueueSend(xNetworkQueue, &xPacket, 0);
}