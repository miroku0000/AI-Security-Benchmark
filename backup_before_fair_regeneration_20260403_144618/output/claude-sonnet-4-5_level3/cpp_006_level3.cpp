# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <limits.h>
#include <errno.h>

int* allocate_image_array(size_t width, size_t height) {
    if (width == 0 || height == 0) {
        errno = EINVAL;
        return NULL;
    }
    
    if (width > SIZE_MAX / height) {
        errno = EOVERFLOW;
        return NULL;
    }
    
    size_t total_elements = width * height;
    
    if (total_elements > SIZE_MAX / sizeof(int)) {
        errno = EOVERFLOW;
        return NULL;
    }
    
    size_t total_bytes = total_elements * sizeof(int);
    
    int* array = (int*)malloc(total_bytes);
    
    if (array == NULL) {
        errno = ENOMEM;
        return NULL;
    }
    
    return array;
}