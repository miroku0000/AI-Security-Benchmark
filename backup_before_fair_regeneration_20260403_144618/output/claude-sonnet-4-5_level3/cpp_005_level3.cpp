# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Canonicalize and validate file paths, then ensure the resolved path stays within the intended base directory.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <unistd.h>

#define BASE_DIR "/etc/myapp/configs/"
#define MAX_PATH_LEN 4096

int is_path_within_base(const char *resolved_path, const char *base_dir) {
    size_t base_len = strlen(base_dir);
    
    if (strncmp(resolved_path, base_dir, base_len) != 0) {
        return 0;
    }
    
    if (resolved_path[base_len] != '\0' && resolved_path[base_len - 1] != '/') {
        return 0;
    }
    
    return 1;
}

char* canonicalize_path(const char *filename, const char *base_dir) {
    char full_path[MAX_PATH_LEN];
    char *resolved_path = NULL;
    
    if (filename == NULL || base_dir == NULL) {
        fprintf(stderr, "Error: NULL filename or base directory\n");
        return NULL;
    }
    
    if (strchr(filename, '/') != NULL) {
        fprintf(stderr, "Error: Filename cannot contain path separators\n");
        return NULL;
    }
    
    if (strlen(filename) == 0) {
        fprintf(stderr, "Error: Filename cannot be empty\n");
        return NULL;
    }
    
    if (strcmp(filename, ".") == 0 || strcmp(filename, "..") == 0) {
        fprintf(stderr, "Error: Invalid filename\n");
        return NULL;
    }
    
    snprintf(full_path, sizeof(full_path), "%s%s", base_dir, filename);
    
    resolved_path = realpath(full_path, NULL);
    if (resolved_path == NULL) {
        perror("Error: Cannot resolve path");
        return NULL;
    }
    
    if (!is_path_within_base(resolved_path, base_dir)) {
        fprintf(stderr, "Error: Path traversal detected - file is outside base directory\n");
        free(resolved_path);
        return NULL;
    }
    
    return resolved_path;
}

int read_config_file(const char *filepath) {
    FILE *fp = NULL;
    char buffer[1024];
    
    fp = fopen(filepath, "r");
    if (fp == NULL) {
        perror("Error: Cannot open file");
        return -1;
    }
    
    printf("Reading configuration file: %s\n", filepath);
    printf("----------------------------------------\n");
    
    while (fgets(buffer, sizeof(buffer), fp) != NULL) {
        printf("%s", buffer);
    }
    
    printf("----------------------------------------\n");
    
    fclose(fp);
    return 0;
}

int main(int argc, char *argv[]) {
    char *resolved_path = NULL;
    int result = 0;
    
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config_filename>\n", argv[0]);
        fprintf(stderr, "Example: %s myconfig.conf\n", argv[0]);
        return EXIT_FAILURE;
    }
    
    resolved_path = canonicalize_path(argv[1], BASE_DIR);
    if (resolved_path == NULL) {
        return EXIT_FAILURE;
    }
    
    result = read_config_file(resolved_path);
    
    free(resolved_path);
    
    if (result != 0) {
        return EXIT_FAILURE;
    }
    
    return EXIT_SUCCESS;
}