# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct ConfigData {
    char** keys;
    char** values;
    size_t count;
    size_t capacity;
} ConfigData;

ConfigData* config_create(size_t initial_capacity) {
    ConfigData* config = (ConfigData*)malloc(sizeof(ConfigData));
    if (!config) {
        return NULL;
    }
    
    config->keys = (char**)malloc(initial_capacity * sizeof(char*));
    config->values = (char**)malloc(initial_capacity * sizeof(char*));
    
    if (!config->keys || !config->values) {
        free(config->keys);
        free(config->values);
        free(config);
        return NULL;
    }
    
    config->count = 0;
    config->capacity = initial_capacity;
    
    return config;
}

void config_destroy(ConfigData* config) {
    if (!config) {
        return;
    }
    
    for (size_t i = 0; i < config->count; i++) {
        free(config->keys[i]);
        free(config->values[i]);
    }
    
    free(config->keys);
    free(config->values);
    free(config);
}

int config_add_entry(ConfigData* config, const char* key, const char* value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity * 2;
        char** new_keys = (char**)realloc(config->keys, new_capacity * sizeof(char*));
        char** new_values = (char**)realloc(config->values, new_capacity * sizeof(char*));
        
        if (!new_keys || !new_values) {
            return 0;
        }
        
        config->keys = new_keys;
        config->values = new_values;
        config->capacity = new_capacity;
    }
    
    config->keys[config->count] = strdup(key);
    config->values[config->count] = strdup(value);
    
    if (!config->keys[config->count] || !config->values[config->count]) {
        free(config->keys[config->count]);
        free(config->values[config->count]);
        return 0;
    }
    
    config->count++;
    return 1;
}

char* trim_whitespace(char* str) {
    char* end;
    
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r') {
        str++;
    }
    
    if (*str == 0) {
        return str;
    }
    
    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r')) {
        end--;
    }
    
    *(end + 1) = '\0';
    
    return str;
}

ConfigData* read_config_file(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    ConfigData* config = config_create(16);
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    char line[1024];
    while (fgets(line, sizeof(line), file)) {
        char* trimmed = trim_whitespace(line);
        
        if (trimmed[0] == '\0' || trimmed[0] == '#' || trimmed[0] == ';') {
            continue;
        }
        
        char* delimiter = strchr(trimmed, '=');
        if (!delimiter) {
            continue;
        }
        
        *delimiter = '\0';
        char* key = trim_whitespace(trimmed);
        char* value = trim_whitespace(delimiter + 1);
        
        if (key[0] != '\0') {
            if (!config_add_entry(config, key, value)) {
                config_destroy(config);
                fclose(file);
                return NULL;
            }
        }
    }
    
    fclose(file);
    return config;
}

const char* config_get_value(const ConfigData* config, const char* key) {
    if (!config || !key) {
        return NULL;
    }
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->keys[i], key) == 0) {
            return config->values[i];
        }
    }
    
    return NULL;
}