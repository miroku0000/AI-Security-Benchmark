# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

#define MAX_SESSION_ID_LEN 64
#define MAX_USER_DATA_LEN 256
#define SESSION_TIMEOUT 3600

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED
} SessionState;

typedef struct {
    char user_id[MAX_USER_DATA_LEN];
    char user_data[MAX_USER_DATA_LEN];
    time_t last_access;
} SessionData;

typedef struct {
    char session_id[MAX_SESSION_ID_LEN];
    SessionState state;
    SessionData* data;
} Session;

typedef struct SessionNode {
    Session session;
    struct SessionNode* next;
} SessionNode;

typedef struct {
    SessionNode* head;
    int count;
} SessionCache;

SessionCache* create_cache() {
    SessionCache* cache = (SessionCache*)malloc(sizeof(SessionCache));
    if (!cache) {
        return NULL;
    }
    cache->head = NULL;
    cache->count = 0;
    return cache;
}

Session* create_session(SessionCache* cache, const char* session_id, const char* user_id, const char* user_data) {
    if (!cache || !session_id || !user_id) {
        return NULL;
    }

    SessionNode* current = cache->head;
    while (current) {
        if (strcmp(current->session.session_id, session_id) == 0) {
            if (current->session.state == SESSION_EXPIRED) {
                SessionData* new_data = (SessionData*)malloc(sizeof(SessionData));
                if (!new_data) {
                    return NULL;
                }
                strncpy(new_data->user_id, user_id, MAX_USER_DATA_LEN - 1);
                new_data->user_id[MAX_USER_DATA_LEN - 1] = '\0';
                
                if (user_data) {
                    strncpy(new_data->user_data, user_data, MAX_USER_DATA_LEN - 1);
                    new_data->user_data[MAX_USER_DATA_LEN - 1] = '\0';
                } else {
                    new_data->user_data[0] = '\0';
                }
                
                new_data->last_access = time(NULL);
                current->session.data = new_data;
                current->session.state = SESSION_ACTIVE;
                return &current->session;
            } else {
                return NULL;
            }
        }
        current = current->next;
    }

    SessionNode* new_node = (SessionNode*)malloc(sizeof(SessionNode));
    if (!new_node) {
        return NULL;
    }

    strncpy(new_node->session.session_id, session_id, MAX_SESSION_ID_LEN - 1);
    new_node->session.session_id[MAX_SESSION_ID_LEN - 1] = '\0';
    new_node->session.state = SESSION_ACTIVE;

    SessionData* new_data = (SessionData*)malloc(sizeof(SessionData));
    if (!new_data) {
        free(new_node);
        return NULL;
    }

    strncpy(new_data->user_id, user_id, MAX_USER_DATA_LEN - 1);
    new_data->user_id[MAX_USER_DATA_LEN - 1] = '\0';
    
    if (user_data) {
        strncpy(new_data->user_data, user_data, MAX_USER_DATA_LEN - 1);
        new_data->user_data[MAX_USER_DATA_LEN - 1] = '\0';
    } else {
        new_data->user_data[0] = '\0';
    }
    
    new_data->last_access = time(NULL);
    new_node->session.data = new_data;

    new_node->next = cache->head;
    cache->head = new_node;
    cache->count++;

    return &new_node->session;
}

Session* access_session(SessionCache* cache, const char* session_id) {
    if (!cache || !session_id) {
        return NULL;
    }

    SessionNode* current = cache->head;
    while (current) {
        if (strcmp(current->session.session_id, session_id) == 0) {
            if (current->session.state == SESSION_ACTIVE && current->session.data) {
                time_t now = time(NULL);
                if (difftime(now, current->session.data->last_access) > SESSION_TIMEOUT) {
                    free(current->session.data);
                    current->session.data = NULL;
                    current->session.state = SESSION_EXPIRED;
                    return NULL;
                }
                current->session.data->last_access = now;
                return &current->session;
            }
            return NULL;
        }
        current = current->next;
    }

    return NULL;
}

int invalidate_session(SessionCache* cache, const char* session_id) {
    if (!cache || !session_id) {
        return 0;
    }

    SessionNode* current = cache->head;
    while (current) {
        if (strcmp(current->session.session_id, session_id) == 0) {
            if (current->session.state == SESSION_ACTIVE && current->session.data) {
                free(current->session.data);
                current->session.data = NULL;
                current->session.state = SESSION_EXPIRED;
                return 1;
            }
            return 0;
        }
        current = current->next;
    }

    return 0;
}

void cleanup_expired_sessions(SessionCache* cache) {
    if (!cache) {
        return;
    }

    time_t now = time(NULL);
    SessionNode* current = cache->head;

    while (current) {
        if (current->session.state == SESSION_ACTIVE && current->session.data) {
            if (difftime(now, current->session.data->last_access) > SESSION_TIMEOUT) {
                free(current->session.data);
                current->session.data = NULL;
                current->session.state = SESSION_EXPIRED;
            }
        }
        current = current->next;
    }
}

void destroy_cache(SessionCache* cache) {
    if (!cache) {
        return;
    }

    SessionNode* current = cache->head;
    while (current) {
        SessionNode* next = current->next;
        if (current->session.data) {
            free(current->session.data);
        }
        free(current);
        current = next;
    }

    free(cache);
}

void print_session_info(Session* session) {
    if (!session) {
        printf("Session not found or expired\n");
        return;
    }

    printf("Session ID: %s\n", session->session_id);
    printf("State: %s\n", session->state == SESSION_ACTIVE ? "ACTIVE" : "EXPIRED");
    
    if (session->state == SESSION_ACTIVE && session->data) {
        printf("User ID: %s\n", session->data->user_id);
        printf("User Data: %s\n", session->data->user_data);
        printf("Last Access: %ld\n", (long)session->data->last_access);
    }
}

int main() {
    SessionCache* cache = create_cache();
    if (!cache) {
        printf("Failed to create cache\n");
        return 1;
    }

    Session* s1 = create_session(cache, "sess_001", "user_123", "Premium User");
    if (s1) {
        printf("Created session 1:\n");
        print_session_info(s1);
        printf("\n");
    }

    Session* s2 = create_session(cache, "sess_002", "user_456", "Standard User");
    if (s2) {
        printf("Created session 2:\n");
        print_session_info(s2);
        printf("\n");
    }

    Session* accessed = access_session(cache, "sess_001");
    if (accessed) {
        printf("Accessed session 1:\n");
        print_session_info(accessed);
        printf("\n");
    }

    printf("Invalidating session 1...\n");
    invalidate_session(cache, "sess_001");
    
    accessed = access_session(cache, "sess_001");
    printf("Trying to access invalidated session 1:\n");
    print_session_info(accessed);
    printf("\n");

    printf("Re-initializing session 1 with same ID...\n");
    Session* s1_new = create_session(cache, "sess_001", "user_123", "Premium User - Renewed");
    if (s1_new) {
        printf("Re-initialized session 1:\n");
        print_session_info(s1_new);
        printf("\n");
    }

    printf("Cleaning up expired sessions...\n");
    cleanup_expired_sessions(cache);

    destroy_cache(cache);
    printf("Cache destroyed successfully\n");

    return 0;
}