# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Use platform-appropriate secure techniques to prevent debug interface.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>
#include <stdbool.h>

#define UART_BASE_ADDR 0x40004000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE_ADDR + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE_ADDR + 0x28))
#define UART_LCRH (*(volatile uint32_t*)(UART_BASE_ADDR + 0x2C))
#define UART_CR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x30))

#define FLASH_BASE_ADDR 0x08000000
#define CONFIG_BASE_ADDR 0x0801F000
#define SECURE_FLAG_ADDR 0x0801FFF0

#define GPIO_BASE 0x40020000
#define GPIOA_MODER (*(volatile uint32_t*)(GPIO_BASE + 0x00))
#define GPIOA_PUPDR (*(volatile uint32_t*)(GPIO_BASE + 0x0C))

#define CMD_BUFFER_SIZE 128
#define MAX_DUMP_SIZE 256
#define AUTH_TOKEN_SIZE 32
#define CHALLENGE_SIZE 16

typedef struct {
    uint8_t auth_token[AUTH_TOKEN_SIZE];
    uint32_t session_timeout;
    uint8_t challenge[CHALLENGE_SIZE];
    bool authenticated;
    uint32_t failed_attempts;
    uint32_t lockout_time;
} security_context_t;

typedef struct {
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t sensor_type;
    uint32_t calibration_data[16];
    uint32_t network_config[8];
    uint32_t crc32;
} device_config_t;

static security_context_t sec_ctx = {0};
static char cmd_buffer[CMD_BUFFER_SIZE];
static uint8_t cmd_index = 0;
static volatile uint32_t system_tick = 0;

void systick_handler(void) {
    system_tick++;
    
    if (sec_ctx.authenticated && sec_ctx.session_timeout > 0) {
        sec_ctx.session_timeout--;
        if (sec_ctx.session_timeout == 0) {
            sec_ctx.authenticated = false;
        }
    }
    
    if (sec_ctx.lockout_time > 0) {
        sec_ctx.lockout_time--;
    }
}

uint32_t calculate_crc32(const uint8_t* data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1) {
                crc = (crc >> 1) ^ 0xEDB88320;
            } else {
                crc >>= 1;
            }
        }
    }
    return ~crc;
}

void generate_challenge(uint8_t* challenge) {
    uint32_t seed = system_tick;
    for (int i = 0; i < CHALLENGE_SIZE; i++) {
        seed = seed * 1103515245 + 12345;
        challenge[i] = (seed >> 16) & 0xFF;
    }
}

bool verify_response(const uint8_t* response, uint32_t response_len) {
    if (response_len != AUTH_TOKEN_SIZE) {
        return false;
    }
    
    uint8_t expected[AUTH_TOKEN_SIZE];
    for (int i = 0; i < AUTH_TOKEN_SIZE; i++) {
        if (i < CHALLENGE_SIZE) {
            expected[i] = sec_ctx.challenge[i] ^ sec_ctx.auth_token[i];
        } else {
            expected[i] = sec_ctx.auth_token[i];
        }
    }
    
    uint32_t expected_crc = calculate_crc32(expected, AUTH_TOKEN_SIZE);
    uint32_t response_crc = calculate_crc32(response, response_len);
    
    return (expected_crc == response_crc) && 
           (memcmp(expected, response, AUTH_TOKEN_SIZE) == 0);
}

void disable_jtag(void) {
    GPIOA_MODER &= ~(0x3 << (13 * 2));
    GPIOA_MODER &= ~(0x3 << (14 * 2));
    GPIOA_MODER &= ~(0x3 << (15 * 2));
    
    GPIOA_PUPDR &= ~(0x3 << (13 * 2));
    GPIOA_PUPDR &= ~(0x3 << (14 * 2));
    GPIOA_PUPDR &= ~(0x3 << (15 * 2));
    GPIOA_PUPDR |= (0x1 << (13 * 2));
    GPIOA_PUPDR |= (0x1 << (14 * 2));
    GPIOA_PUPDR |= (0x1 << (15 * 2));
}

void enable_jtag_secure(void) {
    if (!sec_ctx.authenticated) {
        return;
    }
    
    GPIOA_MODER &= ~(0x3 << (13 * 2));
    GPIOA_MODER &= ~(0x3 << (14 * 2));
    GPIOA_MODER &= ~(0x3 << (15 * 2));
    GPIOA_MODER |= (0x2 << (13 * 2));
    GPIOA_MODER |= (0x2 << (14 * 2));
    GPIOA_MODER |= (0x2 << (15 * 2));
}

void uart_init(uint32_t baudrate) {
    UART_CR = 0;
    
    uint32_t clock = 16000000;
    uint32_t div = (clock * 4) / baudrate;
    UART_IBRD = div >> 6;
    UART_FBRD = div & 0x3F;
    
    UART_LCRH = (0x3 << 5);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & (1 << 5));
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & (1 << 4));
    return UART_DR & 0xFF;
}

void uart_print_hex(uint32_t value) {
    char hex[] = "0123456789ABCDEF";
    uart_puts("0x");
    for (int i = 7; i >= 0; i--) {
        uart_putc(hex[(value >> (i * 4)) & 0xF]);
    }
}

void load_security_config(void) {
    volatile uint32_t* secure_flag = (volatile uint32_t*)SECURE_FLAG_ADDR;
    
    if (*secure_flag == 0xDEADBEEF) {
        for (int i = 0; i < AUTH_TOKEN_SIZE; i++) {
            sec_ctx.auth_token[i] = ((volatile uint8_t*)(SECURE_FLAG_ADDR + 4))[i];
        }
    } else {
        for (int i = 0; i < AUTH_TOKEN_SIZE; i++) {
            sec_ctx.auth_token[i] = 0xA5 ^ i;
        }
    }
    
    sec_ctx.authenticated = false;
    sec_ctx.failed_attempts = 0;
    sec_ctx.lockout_time = 0;
}

bool is_production_mode(void) {
    volatile uint32_t* prod_flag = (volatile uint32_t*)(SECURE_FLAG_ADDR + 64);
    return (*prod_flag == 0xCAFEBABE);
}

void cmd_authenticate(const char* args) {
    if (sec_ctx.lockout_time > 0) {
        uart_puts("ERROR: Account locked. Try again later.\n");
        return;
    }
    
    if (sec_ctx.authenticated) {
        uart_puts("Already authenticated.\n");
        return;
    }
    
    generate_challenge(sec_ctx.challenge);
    
    uart_puts("Challenge: ");
    for (int i = 0; i < CHALLENGE_SIZE; i++) {
        uart_print_hex(sec_ctx.challenge[i]);
        uart_putc(' ');
    }
    uart_puts("\nEnter response: ");
    
    uint8_t response[AUTH_TOKEN_SIZE];
    for (int i = 0; i < AUTH_TOKEN_SIZE; i++) {
        char c1 = uart_getc();
        char c2 = uart_getc();
        uint8_t val = 0;
        if (c1 >= '0' && c1 <= '9') val = (c1 - '0') << 4;
        else if (c1 >= 'A' && c1 <= 'F') val = (c1 - 'A' + 10) << 4;
        else if (c1 >= 'a' && c1 <= 'f') val = (c1 - 'a' + 10) << 4;
        
        if (c2 >= '0' && c2 <= '9') val |= (c2 - '0');
        else if (c2 >= 'A' && c2 <= 'F') val |= (c2 - 'A' + 10);
        else if (c2 >= 'a' && c2 <= 'f') val |= (c2 - 'a' + 10);
        
        response[i] = val;
    }
    uart_puts("\n");
    
    if (verify_response(response, AUTH_TOKEN_SIZE)) {
        sec_ctx.authenticated = true;
        sec_ctx.session_timeout = 300000;
        sec_ctx.failed_attempts = 0;
        uart_puts("Authentication successful. Session timeout: 5 minutes.\n");
    } else {
        sec_ctx.failed_attempts++;
        if (sec_ctx.failed_attempts >= 3) {
            sec_ctx.lockout_time = 60000;
            uart_puts("Too many failed attempts. Locked for 1 minute.\n");
        } else {
            uart_puts("Authentication failed.\n");
        }
    }
}

void cmd_dump_memory(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required.\n");
        return;
    }
    
    uint32_t addr = 0;
    uint32_t length = 64;
    
    if (args && *args) {
        addr = 0;
        while (*args >= '0' && *args <= '9') {
            addr = addr * 10 + (*args - '0');
            args++;
        }
        
        while (*args == ' ') args++;
        
        if (*args) {
            length = 0;
            while (*args >= '0' && *args <= '9') {
                length = length * 10 + (*args - '0');
                args++;
            }
        }
    }
    
    if (length > MAX_DUMP_SIZE) {
        length = MAX_DUMP_SIZE;
    }
    
    if (addr < 0x20000000 || addr >= 0x20020000) {
        uart_puts("ERROR: Address out of safe range (RAM only).\n");
        return;
    }
    
    uart_puts("Memory dump:\n");
    volatile uint8_t* ptr = (volatile uint8_t*)addr;
    
    for (uint32_t i = 0; i < length; i += 16) {
        uart_print_hex(addr + i);
        uart_puts(": ");
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            uint8_t val = ptr[i + j];
            char hex[] = "0123456789ABCDEF";
            uart_putc(hex[(val >> 4) & 0xF]);
            uart_putc(hex[val & 0xF]);
            uart_putc(' ');
        }
        uart_puts("\n");
    }
}

void cmd_read_flash(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required.\n");
        return;
    }
    
    uint32_t offset = 0;
    uint32_t length = 64;
    
    if (args && *args) {
        offset = 0;
        while (*args >= '0' && *args <= '9') {
            offset = offset * 10 + (*args - '0');
            args++;
        }
        
        while (*args == ' ') args++;
        
        if (*args) {
            length = 0;
            while (*args >= '0' && *args <= '9') {
                length = length * 10 + (*args - '0');
                args++;
            }
        }
    }
    
    if (length > MAX_DUMP_SIZE) {
        length = MAX_DUMP_SIZE;
    }
    
    if (offset >= 0x20000) {
        uart_puts("ERROR: Offset out of range.\n");
        return;
    }
    
    uint32_t addr = FLASH_BASE_ADDR + offset;
    if (addr >= SECURE_FLAG_ADDR && addr < (SECURE_FLAG_ADDR + 256)) {
        uart_puts("ERROR: Access to secure region denied.\n");
        return;
    }
    
    uart_puts("Flash read:\n");
    volatile uint8_t* ptr = (volatile uint8_t*)addr;
    
    for (uint32_t i = 0; i < length; i += 16) {
        uart_print_hex(addr + i);
        uart_puts(": ");
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            uint8_t val = ptr[i + j];
            char hex[] = "0123456789ABCDEF";
            uart_putc(hex[(val >> 4) & 0xF]);
            uart_putc(hex[val & 0xF]);
            uart_putc(' ');
        }
        uart_puts("\n");
    }
}

void cmd_get_config(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required.\n");
        return;
    }
    
    volatile device_config_t* config = (volatile device_config_t*)CONFIG_BASE_ADDR;
    
    uint32_t calc_crc = calculate_crc32((const uint8_t*)config, 
                                        sizeof(device_config_t) - sizeof(uint32_t));
    
    if (calc_crc != config->crc32) {
        uart_puts("WARNING: Configuration CRC mismatch!\n");
    }
    
    uart_puts("Device Configuration:\n");
    uart_puts("Device ID: ");
    uart_print_hex(config->device_id);
    uart_puts("\nFirmware Version: ");
    uart_print_hex(config->firmware_version);
    uart_puts("\nSensor Type: ");
    uart_print_hex(config->sensor_type);
    uart_puts("\n\nCalibration Data:\n");
    
    for (int i = 0; i < 16; i++) {
        uart_puts("  [");
        uart_print_hex(i);
        uart_puts("]: ");
        uart_print_hex(config->calibration_data[i]);
        uart_puts("\n");
    }
    
    uart_puts("\nNetwork Configuration:\n");
    for (int i = 0; i < 8; i++) {
        uart_puts("  [");
        uart_print_hex(i);
        uart_puts("]: ");
        uart_print_hex(config->network_config[i]);
        uart_puts("\n");
    }
    
    uart_puts("CRC32: ");
    uart_print_hex(config->crc32);
    uart_puts("\n");
}

void cmd_enable_jtag(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required.\n");
        return;
    }
    
    if (is_production_mode()) {
        uart_puts("ERROR: JTAG disabled in production mode.\n");
        return;
    }
    
    enable_jtag_secure();
    uart_puts("JTAG interface enabled for this session.\n");
}

void cmd_disable_jtag(const char* args) {
    disable_jtag();
    uart_puts("JTAG interface disabled.\n");
}

void cmd_status(const char* args) {
    uart_puts("System Status:\n");
    uart_puts("Authentication: ");
    uart_puts(sec_ctx.authenticated ? "Authenticated\n" : "Not authenticated\n");
    
    if (sec_ctx.authenticated) {
        uart_puts("Session timeout: ");
        uart_print_hex(sec_ctx.session_timeout);
        uart_puts(" ms\n");
    }
    
    uart_puts("Failed attempts: ");
    uart_print_hex(sec_ctx.failed_attempts);
    uart_puts("\n");
    
    if (sec_ctx.lockout_time > 0) {
        uart_puts("Lockout time: ");
        uart_print_hex(sec_ctx.lockout_time);
        uart_puts(" ms\n");
    }
    
    uart_puts("Production mode: ");
    uart_puts(is_production_mode() ? "Yes\n" : "No\n");
    
    uart_puts("System tick: ");
    uart_print_hex(system_tick);
    uart_puts("\n");
}

void cmd_help(const char* args) {
    uart_puts("\nAvailable commands:\n");
    uart_puts("  auth              - Authenticate session\n");
    uart_puts("  dump_memory <addr> <len> - Dump RAM memory\n");
    uart_puts("  read_flash <offset> <len> - Read flash memory\n");
    uart_puts("  get_config        - Display device configuration\n");
    uart_puts("  enable_jtag       - Enable JTAG interface (dev mode only)\n");
    uart_puts("  disable_jtag      - Disable JTAG interface\n");
    uart_puts("  status            - Show system status\n");
    uart_puts("  help              - Show this help\n");
    uart_puts("\nNote: Most commands require authentication.\n");
}

void process_command(const char* cmd) {
    char cmd_name[32] = {0};
    const char* args = NULL;
    int i = 0;
    
    while (*cmd == ' ') cmd++;
    
    while (*cmd && *cmd != ' ' && i < 31) {
        cmd_name[i++] = *cmd++;
    }
    cmd_name[i] = '\0';
    
    while (*cmd == ' ') cmd++;
    if (*cmd) {
        args = cmd;
    }
    
    if (strcmp(cmd_name, "auth") == 0) {
        cmd_authenticate(args);
    } else if (strcmp(cmd_name, "dump_memory") == 0) {
        cmd_dump_memory(args);
    } else if (strcmp(cmd_name, "read_flash") == 0) {
        cmd_read_flash(args);
    } else if (strcmp(cmd_name, "get_config") == 0) {
        cmd_get_config(args);
    } else if (strcmp(cmd_name, "enable_jtag") == 0) {
        cmd_enable_jtag(args);
    } else if (strcmp(cmd_name, "disable_jtag") == 0) {
        cmd_disable_jtag(args);
    } else if (strcmp(cmd_name, "status") == 0) {
        cmd_status(args);
    } else if (strcmp(cmd_name, "help") == 0) {
        cmd_help(args);
    } else if (strlen(cmd_name) > 0) {
        uart_puts("Unknown command. Type 'help' for available commands.\n");
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    load_security_config();
    disable_jtag();
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Sensor Diagnostic Console\n");
    uart_puts("  Firmware Version: 1.0.0\n");
    uart_puts("========================================\n");
    uart_puts("\nWARNING: Unauthorized access is prohibited.\n");
    uart_puts("All activities are logged and monitored.\n\n");
    
    if (is_production_mode()) {
        uart_puts("Running in PRODUCTION mode.\n");
        uart_puts("Enhanced security features enabled.\n\n");
    } else {
        uart_puts("Running in DEVELOPMENT mode.\n\n");
    }
    
    uart_puts("Type 'help' for available commands.\n");
}

void diagnostic_console_task(void) {
    if (!(UART_FR & (1 << 4))) {
        char c = UART_DR & 0xFF;
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            cmd_buffer[cmd_index] = '\0';
            
            if (cmd_index > 0) {
                process_command(cmd_buffer);
            }
            
            cmd_index = 0;
            uart_puts("\n> ");
        } else if (c == 127 || c == 8) {
            if (cmd_index > 0) {
                cmd_index--;
                uart_puts("\b \b");
            }
        } else if (c >= 32 && c < 127) {
            if (cmd_index < CMD_BUFFER_SIZE - 1) {
                cmd_buffer[cmd_index++] = c;
                uart_putc(c);
            }
        }
    }
}

void main(void) {
    diagnostic_console_init();
    
    uart_puts("> ");
    
    while (1) {
        diagnostic_console_task();
    }
}