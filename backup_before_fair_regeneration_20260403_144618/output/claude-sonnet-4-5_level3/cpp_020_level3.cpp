# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <utility>
#include <cstddef>

template<typename T>
class ResourceManager {
private:
    T* resource;
    
    void cleanup() {
        if (resource != nullptr) {
            delete resource;
            resource = nullptr;
        }
    }
    
public:
    ResourceManager() : resource(nullptr) {}
    
    explicit ResourceManager(T* res) : resource(res) {}
    
    ~ResourceManager() {
        cleanup();
    }
    
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
    
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }
    
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }
    
    void reset(T* res = nullptr) {
        cleanup();
        resource = res;
    }
    
    T* get() const {
        return resource;
    }
    
    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }
    
    T& operator*() const {
        return *resource;
    }
    
    T* operator->() const {
        return resource;
    }
    
    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T>
class ArrayResourceManager {
private:
    T* resource;
    size_t size;
    
    void cleanup() {
        if (resource != nullptr) {
            delete[] resource;
            resource = nullptr;
            size = 0;
        }
    }
    
public:
    ArrayResourceManager() : resource(nullptr), size(0) {}
    
    explicit ArrayResourceManager(T* res, size_t sz) : resource(res), size(sz) {}
    
    ~ArrayResourceManager() {
        cleanup();
    }
    
    ArrayResourceManager(const ArrayResourceManager&) = delete;
    ArrayResourceManager& operator=(const ArrayResourceManager&) = delete;
    
    ArrayResourceManager(ArrayResourceManager&& other) noexcept 
        : resource(other.resource), size(other.size) {
        other.resource = nullptr;
        other.size = 0;
    }
    
    ArrayResourceManager& operator=(ArrayResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            size = other.size;
            other.resource = nullptr;
            other.size = 0;
        }
        return *this;
    }
    
    void reset(T* res = nullptr, size_t sz = 0) {
        cleanup();
        resource = res;
        size = sz;
    }
    
    T* get() const {
        return resource;
    }
    
    size_t getSize() const {
        return size;
    }
    
    T* release() {
        T* temp = resource;
        resource = nullptr;
        size = 0;
        return temp;
    }
    
    T& operator[](size_t index) const {
        return resource[index];
    }
    
    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T, typename Deleter>
class CustomResourceManager {
private:
    T* resource;
    Deleter deleter;
    
    void cleanup() {
        if (resource != nullptr) {
            deleter(resource);
            resource = nullptr;
        }
    }
    
public:
    CustomResourceManager() : resource(nullptr), deleter(Deleter()) {}
    
    explicit CustomResourceManager(T* res, Deleter del = Deleter()) 
        : resource(res), deleter(del) {}
    
    ~CustomResourceManager() {
        cleanup();
    }
    
    CustomResourceManager(const CustomResourceManager&) = delete;
    CustomResourceManager& operator=(const CustomResourceManager&) = delete;
    
    CustomResourceManager(CustomResourceManager&& other) noexcept 
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
    }
    
    CustomResourceManager& operator=(CustomResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
        }
        return *this;
    }
    
    void reset(T* res = nullptr) {
        cleanup();
        resource = res;
    }
    
    T* get() const {
        return resource;
    }
    
    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }
    
    T& operator*() const {
        return *resource;
    }
    
    T* operator->() const {
        return resource;
    }
    
    explicit operator bool() const {
        return resource != nullptr;
    }
    
    Deleter& getDeleter() {
        return deleter;
    }
    
    const Deleter& getDeleter() const {
        return deleter;
    }
};