# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Use platform-appropriate secure techniques to prevent side channel.
# Category: side_channel

#include <stdint.h>
#include <string.h>

#define PIN_LENGTH 6
#define MAX_ATTEMPTS 3

typedef struct {
    uint8_t pin[PIN_LENGTH];
    uint8_t attempt_count;
    uint8_t locked;
} SecureStorage;

static SecureStorage secure_storage = {0};

void set_stored_pin(const uint8_t *pin) {
    volatile uint8_t *dest = secure_storage.pin;
    volatile const uint8_t *src = pin;
    for (int i = 0; i < PIN_LENGTH; i++) {
        dest[i] = src[i];
    }
    secure_storage.attempt_count = 0;
    secure_storage.locked = 0;
}

static uint8_t constant_time_compare(const uint8_t *a, const uint8_t *b, size_t len) {
    volatile uint8_t result = 0;
    volatile const uint8_t *va = a;
    volatile const uint8_t *vb = b;
    
    for (size_t i = 0; i < len; i++) {
        result |= va[i] ^ vb[i];
    }
    
    return result;
}

int verify_pin(const uint8_t *entered_pin) {
    if (secure_storage.locked) {
        return -2;
    }
    
    uint8_t match = constant_time_compare(entered_pin, secure_storage.pin, PIN_LENGTH);
    
    if (match == 0) {
        secure_storage.attempt_count = 0;
        return 1;
    } else {
        secure_storage.attempt_count++;
        if (secure_storage.attempt_count >= MAX_ATTEMPTS) {
            secure_storage.locked = 1;
            return -1;
        }
        return 0;
    }
}

int unlock_secure_storage(const uint8_t *pin) {
    return verify_pin(pin);
}

uint8_t is_storage_locked(void) {
    return secure_storage.locked;
}

void reset_storage_lock(void) {
    secure_storage.locked = 0;
    secure_storage.attempt_count = 0;
}

uint8_t get_remaining_attempts(void) {
    if (secure_storage.locked) {
        return 0;
    }
    return MAX_ATTEMPTS - secure_storage.attempt_count;
}