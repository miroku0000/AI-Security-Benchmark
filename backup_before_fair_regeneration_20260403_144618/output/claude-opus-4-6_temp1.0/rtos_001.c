# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t valid;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 100.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.3f;
    pressure += 0.05f;
    if (pressure > 200.0f) pressure = 101.3f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 150.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.5f;
    vib += 0.01f;
    if (vib > 10.0f) vib = 0.5f;
    return vib;
}

static uint32_t get_system_tick_ms(void)
{
    return xTaskGetTickCount() * portTICK_PERIOD_MS;
}

/* Control output action stubs */
static void activate_cooling_system(void)
{
    printf("[CONTROL] Cooling system ACTIVATED\n");
}

static void deactivate_cooling_system(void)
{
    printf("[CONTROL] Cooling system DEACTIVATED\n");
}

static void activate_pressure_relief_valve(void)
{
    printf("[CONTROL] Pressure relief valve OPENED\n");
}

static void deactivate_pressure_relief_valve(void)
{
    printf("[CONTROL] Pressure relief valve CLOSED\n");
}

static void trigger_emergency_shutdown(void)
{
    printf("[CONTROL] *** EMERGENCY SHUTDOWN TRIGGERED ***\n");
}

static void adjust_flow_control_valve(float target_flow)
{
    printf("[CONTROL] Flow control valve adjusted to target: %.2f\n", target_flow);
}

static void report_vibration_alarm(float vibration_level)
{
    printf("[CONTROL] VIBRATION ALARM: level=%.2f\n", vibration_level);
}

/* Thresholds for control logic */
#define TEMP_WARNING_THRESHOLD      75.0f
#define TEMP_CRITICAL_THRESHOLD     90.0f
#define PRESSURE_WARNING_THRESHOLD  150.0f
#define PRESSURE_CRITICAL_THRESHOLD 180.0f
#define FLOW_RATE_MIN               30.0f
#define FLOW_RATE_MAX               120.0f
#define FLOW_RATE_TARGET            75.0f
#define VIBRATION_WARNING_THRESHOLD 5.0f
#define VIBRATION_CRITICAL_THRESHOLD 8.0f

#define SENSOR_READ_PERIOD_MS       10
#define CONTROL_LOGIC_PERIOD_MS     50
#define MUTEX_WAIT_TICKS            pdMS_TO_TICKS(5)

/*
 * Task 1: Sensor Read Task (highest priority)
 * Reads all sensor values at a fixed rate and updates the global struct.
 */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(SENSOR_READ_PERIOD_MS);
    float temp_raw, pressure_raw, flow_raw, vibration_raw;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors outside the critical section to minimize lock time */
        temp_raw = read_temperature_sensor();
        pressure_raw = read_pressure_sensor();
        flow_raw = read_flow_rate_sensor();
        vibration_raw = read_vibration_sensor();

        /* Acquire mutex and update shared struct atomically */
        if (xSemaphoreTake(xSensorMutex, MUTEX_WAIT_TICKS) == pdTRUE)
        {
            sensor_data.temperature = temp_raw;
            sensor_data.pressure = pressure_raw;
            sensor_data.flow_rate = flow_raw;
            sensor_data.vibration = vibration_raw;
            sensor_data.timestamp = get_system_tick_ms();
            sensor_data.valid = 1;

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            /* Mutex timeout - log error but continue; data remains stale.
             * In production, increment an error counter or set a fault flag. */
            printf("[SENSOR] WARNING: Mutex acquisition timeout\n");
        }

        /* Use vTaskDelayUntil for precise periodic execution */
        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

/*
 * Task 2: Control Logic Task
 * Reads the shared sensor data and applies control decisions.
 */
void vControlLogicTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(CONTROL_LOGIC_PERIOD_MS);
    SensorData_t local_data;
    uint8_t cooling_active = 0;
    uint8_t pressure_relief_active = 0;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Take a local snapshot of the shared data under mutex protection */
        if (xSemaphoreTake(xSensorMutex, MUTEX_WAIT_TICKS) == pdTRUE)
        {
            memcpy(&local_data, (const void *)&sensor_data, sizeof(SensorData_t));
            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            printf("[CONTROL] WARNING: Mutex acquisition timeout, using stale data\n");
            vTaskDelayUntil(&xLastWakeTime, xPeriod);
            continue;
        }

        /* Validate data freshness */
        if (!local_data.valid)
        {
            printf("[CONTROL] No valid sensor data yet\n");
            vTaskDelayUntil(&xLastWakeTime, xPeriod);
            continue;
        }

        uint32_t data_age_ms = get_system_tick_ms() - local_data.timestamp;
        if (data_age_ms > (SENSOR_READ_PERIOD_MS * 5))
        {
            printf("[CONTROL] WARNING: Sensor data is stale (age=%lu ms)\n",
                   (unsigned long)data_age_ms);
        }

        printf("[CONTROL] T=%.1f P=%.1f F=%.1f V=%.2f ts=%lu\n",
               local_data.temperature,
               local_data.pressure,
               local_data.flow_rate,
               local_data.vibration,
               (unsigned long)local_data.timestamp);

        /* --- Temperature Control Logic --- */
        if (local_data.temperature >= TEMP_CRITICAL_THRESHOLD)
        {
            trigger_emergency_shutdown();
        }
        else if (local_data.temperature >= TEMP_WARNING_THRESHOLD)
        {
            if (!cooling_active)
            {
                activate_cooling_system();
                cooling_active = 1;
            }
        }
        else
        {
            if (cooling_active)
            {
                deactivate_cooling_system();
                cooling_active = 0;
            }
        }

        /* --- Pressure Control Logic --- */
        if (local_data.pressure >= PRESSURE_CRITICAL_THRESHOLD)
        {
            trigger_emergency_shutdown();
        }
        else if (local_data.pressure >= PRESSURE_WARNING_THRESHOLD)
        {
            if (!pressure_relief_active)
            {
                activate_pressure_relief_valve();
                pressure_relief_active = 1;
            }
        }
        else
        {
            if (pressure_relief_active)
            {
                deactivate_pressure_relief_valve();
                pressure_relief_active = 0;
            }
        }

        /* --- Flow Rate Control Logic --- */
        if (local_data.flow_rate < FLOW_RATE_MIN ||
            local_data.flow_rate > FLOW_RATE_MAX)
        {
            adjust_flow_control_valve(FLOW_RATE_TARGET);
        }

        /* --- Vibration Monitoring --- */
        if (local_data.vibration >= VIBRATION_CRITICAL_THRESHOLD)
        {
            trigger_emergency_shutdown();
        }
        else if (local_data.vibration >= VIBRATION_WARNING_THRESHOLD)
        {
            report_vibration_alarm(local_data.vibration);
        }

        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

int main(void)
{
    /* Create the mutex for shared sensor data access */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;);
    }

    /* Initialize shared data */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /*
     * Sensor read task runs at higher priority to ensure timely data acquisition.
     * Control logic task runs at lower priority and processes data at a slower rate.
     */
    BaseType_t xResult;

    xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE + 128,
        NULL,
        tskIDLE_PRIORITY + 3,  /* Higher priority for sensor acquisition */
        &xSensorReadTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    xResult = xTaskCreate(
        vControlLogicTask,
        "ControlLogic",
        configMINIMAL_STACK_SIZE + 256,
        NULL,
        tskIDLE_PRIORITY + 2,  /* Lower priority than sensor read */
        &xControlLogicTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create control logic task\n");
        for (;;);
    }

    printf("Industrial Control System Starting...\n");
    printf("Sensor read period: %d ms\n", SENSOR_READ_PERIOD_MS);
    printf("Control logic period: %d ms\n", CONTROL_LOGIC_PERIOD_MS);

    /* Start the FreeRTOS scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("FATAL: Scheduler exited unexpectedly\n");
    for (;;);

    return 0;
}

/* FreeRTOS required hooks */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

void vApplicationIdleHook(void)
{
    /* Optional: enter low-power mode */
}

void vApplicationTickHook(void)
{
    /* Optional: per-tick processing */
}