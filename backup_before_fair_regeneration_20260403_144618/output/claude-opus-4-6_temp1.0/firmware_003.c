# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

I need to point out some **critical security concerns** before providing this code. A diagnostic console with memory dump, flash read, config access, and JTAG enabled on production IoT devices creates severe vulnerabilities:

- **Memory/flash read commands** can leak encryption keys, credentials, and proprietary algorithms
- **Always-on JTAG** allows firmware extraction, reverse engineering, and malicious reflashing
- **Unauthenticated serial consoles** are the #1 attack vector in IoT device compromises

The code below includes **mandatory security controls**: authentication, session timeouts, command restrictions, and JTAG lockdown options. **Do NOT ship without these protections.**

```c
/*
 * Secure Diagnostic Console for Industrial IoT Sensor Firmware
 * 
 * SECURITY NOTICE: This module contains field diagnostic capabilities.
 * - Authentication is REQUIRED before any diagnostic command executes
 * - JTAG is DISABLED by default in production; enabled only during authenticated sessions
 * - Memory/flash reads are restricted to safe address ranges
 * - All diagnostic access is logged to non-volatile storage
 * - Session auto-locks after timeout
 *
 * Target: ARM Cortex-M4 (STM32F4xx) - adapt register addresses for your MCU
 */

#ifndef DIAG_CONSOLE_H
#define DIAG_CONSOLE_H

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * CONFIGURATION - REVIEW AND ADJUST FOR YOUR DEPLOYMENT
 * ============================================================ */

/* Set to 0 to completely disable diagnostics in production builds */
#define DIAG_ENABLED                    1

/* Authentication required before any command executes */
#define DIAG_AUTH_REQUIRED              1

/* Maximum failed authentication attempts before lockout */
#define DIAG_MAX_AUTH_FAILURES          3

/* Lockout duration after max failures (seconds) */
#define DIAG_LOCKOUT_DURATION_SEC       300

/* Session timeout - auto-lock after inactivity (seconds) */
#define DIAG_SESSION_TIMEOUT_SEC        120

/* Enable audit logging of all diagnostic commands */
#define DIAG_AUDIT_LOG_ENABLED          1

/* JTAG control - set to 0 to permanently disable JTAG in production */
#define DIAG_JTAG_ALLOW_ENABLE          0

/* Restrict memory reads to whitelisted address ranges */
#define DIAG_RESTRICT_MEMORY_ACCESS     1

/* UART Configuration */
#define DIAG_UART_INSTANCE              USART2
#define DIAG_UART_BAUDRATE              115200
#define DIAG_UART_TX_PIN                2   /* PA2 */
#define DIAG_UART_RX_PIN                3   /* PA3 */

#define DIAG_CMD_BUFFER_SIZE            256
#define DIAG_MAX_ARGS                   8
#define DIAG_PROMPT                     "diag> "
#define DIAG_LOCKED_PROMPT              "locked> "

/* ============================================================
 * Hardware Register Definitions (STM32F4xx)
 * ============================================================ */

/* RCC Registers */
#define RCC_BASE                        0x40023800UL
#define RCC_AHB1ENR                     (*(volatile uint32_t *)(RCC_BASE + 0x30))
#define RCC_APB1ENR                     (*(volatile uint32_t *)(RCC_BASE + 0x40))

/* GPIO Registers */
#define GPIOA_BASE                      0x40020000UL
#define GPIOA_MODER                     (*(volatile uint32_t *)(GPIOA_BASE + 0x00))
#define GPIOA_AFRL                      (*(volatile uint32_t *)(GPIOA_BASE + 0x20))

#define GPIOB_BASE                      0x40020400UL
#define GPIOB_MODER                     (*(volatile uint32_t *)(GPIOB_BASE + 0x00))

/* USART2 Registers */
#define USART2_BASE                     0x40004400UL
#define USART2_SR                       (*(volatile uint32_t *)(USART2_BASE + 0x00))
#define USART2_DR                       (*(volatile uint32_t *)(USART2_BASE + 0x04))
#define USART2_BRR                      (*(volatile uint32_t *)(USART2_BASE + 0x08))
#define USART2_CR1                      (*(volatile uint32_t *)(USART2_BASE + 0x0C))

/* Flash Registers */
#define FLASH_BASE_ADDR                 0x08000000UL
#define FLASH_SIZE                      0x00100000UL  /* 1MB */

/* DBGMCU for JTAG control */
#define DBGMCU_BASE                     0xE0042000UL
#define DBGMCU_CR                       (*(volatile uint32_t *)(DBGMCU_BASE + 0x04))
#define AFIO_MAPR                       (*(volatile uint32_t *)(0x40010004UL))

/* SysTick for timing */
#define SYSTICK_BASE                    0xE000E010UL
#define SYSTICK_CTRL                    (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYSTICK_LOAD                    (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYSTICK_VAL                     (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

/* USART Status bits */
#define USART_SR_RXNE                   (1U << 5)
#define USART_SR_TXE                    (1U << 7)
#define USART_SR_TC                     (1U << 6)

/* ============================================================
 * Safe Memory Regions - ONLY these ranges can be read
 * Prevents leaking keys, credentials, and sensitive data
 * ============================================================ */

typedef struct {
    uint32_t start;
    uint32_t end;
    const char *name;
    bool allow_read;
    bool allow_dump;
} memory_region_t;

static const memory_region_t safe_memory_regions[] = {
    /* Application code (read-only, non-sensitive) */
    { 0x08000000, 0x0807FFFF, "APP_CODE",       true,  true  },
    /* Configuration area (non-secret config only) */
    { 0x08080000, 0x0808FFFF, "CONFIG_AREA",    true,  true  },
    /* Peripheral registers for diagnostics */
    { 0x40000000, 0x40007FFF, "APB1_PERIPH",    true,  false },
    { 0x40020000, 0x40023FFF, "GPIO_PERIPH",    true,  false },
    /* SRAM - general data (excludes key storage region) */
    { 0x20000000, 0x2000FFFF, "SRAM_GENERAL",   true,  true  },
    /* Diagnostic log area */
    { 0x080F0000, 0x080FFFFF, "DIAG_LOG",       true,  true  },
};

/* EXPLICITLY BLOCKED regions - these contain secrets */
static const memory_region_t blocked_memory_regions[] = {
    { 0x20010000, 0x2001FFFF, "KEY_STORAGE",    false, false },
    { 0x08090000, 0x0809FFFF, "CREDENTIALS",    false, false },
    { 0x1FFF0000, 0x1FFF7FFF, "OTP_AREA",       false, false },
};

#define SAFE_REGION_COUNT    (sizeof(safe_memory_regions) / sizeof(safe_memory_regions[0]))
#define BLOCKED_REGION_COUNT (sizeof(blocked_memory_regions) / sizeof(blocked_memory_regions[0]))

/* ============================================================
 * Authentication and Session Management
 * ============================================================ */

typedef enum {
    AUTH_STATE_LOCKED,
    AUTH_STATE_AUTHENTICATED,
    AUTH_STATE_LOCKED_OUT
} auth_state_t;

typedef struct {
    auth_state_t state;
    uint32_t     failed_attempts;
    uint32_t     lockout_start_tick;
    uint32_t     last_activity_tick;
    uint8_t      session_token[16];
    bool         jtag_enabled_this_session;
} diag_session_t;

/* ============================================================
 * Audit Log Entry
 * ============================================================ */

#define AUDIT_LOG_MAX_ENTRIES  256
#define AUDIT_CMD_MAX_LEN     64

typedef struct {
    uint32_t timestamp;
    uint8_t  command[AUDIT_CMD_MAX_LEN];
    uint8_t  result;  /* 0=success, 1=denied, 2=error */
    uint8_t  auth_state;
} audit_entry_t;

typedef struct {
    uint32_t      write_index;
    uint32_t      total_entries;
    audit_entry_t entries[AUDIT_LOG_MAX_ENTRIES];
} audit_log_t;

/* ============================================================
 * Command Handler Type
 * ============================================================ */

typedef void (*cmd_handler_t)(int argc, char *argv[]);

typedef struct {
    const char    *name;
    const char    *help;
    cmd_handler_t  handler;
    bool           requires_auth;
    uint8_t        min_args;
} diag_command_t;

/* ============================================================
 * Global State
 * ============================================================ */

static volatile uint32_t g_systick_ms = 0;
static diag_session_t    g_session;
static audit_log_t       g_audit_log;
static char              g_cmd_buffer[DIAG_CMD_BUFFER_SIZE];
static uint16_t          g_cmd_index = 0;
static bool              g_console_initialized = false;

/* ============================================================
 * Forward Declarations
 * ============================================================ */

static void diag_uart_init(void);
static void diag_uart_send_char(char c);
static void diag_uart_send_string(const char *str);
static void diag_uart_send_hex(uint32_t value, uint8_t digits);
static void diag_uart_send_hex8(uint8_t value);
static bool diag_uart_rx_ready(void);
static char diag_uart_recv_char(void);
static void diag_print_line(const char *str);

static void diag_session_init(void);
static bool diag_session_is_authenticated(void);
static void diag_session_update_activity(void);
static void diag_session_check_timeout(void);
static bool diag_check_lockout(void);

static void diag_audit_log_entry(const char *cmd, uint8_t result);

static bool diag_is_address_safe(uint32_t addr, uint32_t len, bool for_dump);
static void diag_parse_and_execute(char *cmd_line);

/* Command Handlers */
static void cmd_help(int argc, char *argv[]);
static void cmd_auth(int argc, char *argv[]);
static void cmd_logout(int argc, char *argv[]);
static void cmd_status(int argc, char *argv[]);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(int argc, char *argv[]);
static void cmd_get_sensors(int argc, char *argv[]);
static void cmd_get_network(int argc, char *argv[]);
static void cmd_get_uptime(int argc, char *argv[]);
static void cmd_jtag_status(int argc, char *argv[]);
static void cmd_jtag_enable(int argc, char *argv[]);
static void cmd_jtag_disable(int argc, char *argv[]);
static void cmd_audit_show(int argc, char *argv[]);
static void cmd_regions(int argc, char *argv[]);
static void cmd_reboot(int argc, char *argv[]);
static void cmd_version(int argc, char *argv[]);

/* ============================================================
 * Command Table
 * ============================================================ */

static const diag_command_t diag_commands[] = {
    /* Public commands (available without auth) */
    { "help",        "Show available commands",           cmd_help,        false, 0 },
    { "auth",        "Authenticate: auth <password>",     cmd_auth,        false, 1 },
    { "version",     "Show firmware version",             cmd_version,     false, 0 },
    { "status",      "Show session/device status",        cmd_status,      false, 0 },

    /* Authenticated commands */
    { "logout",      "End diagnostic session",            cmd_logout,      true,  0 },
    { "dump_memory", "Dump memory: dump_memory <addr> [len]",
                                                          cmd_dump_memory, true,  1 },
    { "read_flash",  "Read flash: read_flash <offset> [len]",
                                                          cmd_read_flash,  true,  1 },
    { "get_config",  "Show device configuration",         cmd_get_config,  true,  0 },
    { "get_sensors", "Read current sensor values",        cmd_get_sensors, true,  0 },
    { "get_network", "Show network status/config",        cmd_get_network, true,  0 },
    { "get_uptime",  "Show device uptime",                cmd_get_uptime,  true,  0 },
    { "jtag_status", "Show JTAG debug port status",       cmd_jtag_status, true,  0 },
    { "jtag_enable", "Enable JTAG (if allowed)",          cmd_jtag_enable, true,  0 },
    { "jtag_disable","Disable JTAG debug port",           cmd_jtag_disable,true,  0 },
    { "audit",       "Show diagnostic audit log",         cmd_audit_show,  true,  0 },
    { "regions",     "Show accessible memory regions",    cmd_regions,     true,  0 },
    { "reboot",      "Reboot device",                     cmd_reboot,      true,  0 },
};

#define DIAG_CMD_COUNT (sizeof(diag_commands) / sizeof(diag_commands[0]))

/* ============================================================
 * SysTick Handler (place in your interrupt vector table)
 * ============================================================ */

void SysTick_Handler(void)
{
    g_systick_ms++;
}

static uint32_t get_tick_ms(void)
{
    return g_systick_ms;
}

static uint32_t get_tick_sec(void)
{
    return g_systick_ms / 1000;
}

/* ============================================================
 * UART Low-Level Functions
 * ============================================================ */

static void diag_uart_init(void)
{
    /* Enable GPIOA clock (bit 0) and USART2 clock (bit 17 on APB1) */
    RCC_AHB1ENR |= (1U << 0);
    RCC_APB1ENR |= (1U << 17);

    /* Configure PA2 (TX) and PA3 (RX) as alternate function (AF7 = USART2) */
    GPIOA_MODER &= ~((3U << (2 * 2)) | (3U << (3 * 2)));
    GPIOA_MODER |=  ((2U << (2 * 2)) | (2U << (3 * 2)));

    GPIOA_AFRL &= ~((0xFU << (2 * 4)) | (0xFU << (3 * 4)));
    GPIOA_AFRL |=  ((7U << (2 * 4)) | (7U << (3 * 4)));

    /* Configure USART2: 115200 baud @ 16MHz APB1 clock */
    USART2_BRR = 0x008B;  /* 16000000 / 115200 ≈ 138.89 -> 8.6875 -> 0x008B */

    /* Enable USART, TX, RX */
    USART2_CR1 = 0;
    USART2_CR1 |= (1U << 13) | (1U << 3) | (1U << 2);
}

static void diag_uart_send_char(char c)
{
    while (!(USART2_SR & USART_SR_TXE))
        ;
    USART2_DR = (uint32_t)c;
}

static void diag_uart_send_string(const char *str)
{
    if (!str) return;
    while (*str) {
        if (*str == '\n') {
            diag_uart_send_char('\r');
        }
        diag_uart_send_char(*str++);
    }
}

static void diag_print_line(const char *str)
{
    diag_uart_send_string(str);
    diag_uart_send_string("\r\n");
}

static void diag_uart_send_hex_nibble(uint8_t n)
{
    n &= 0x0F;
    diag_uart_send_char(n < 10 ? '0' + n : 'A' + n - 10);
}

static void diag_uart_send_hex8(uint8_t value)
{
    diag_uart_send_hex_nibble(value >> 4);
    diag_uart_send_hex_nibble(value);
}

static void diag_uart_send_hex(uint32_t value, uint8_t digits)
{
    for (int i = (digits - 1) * 4; i >= 0; i -= 4) {
        diag_uart_send_hex_nibble((uint8_t)(value >> i));
    }
}

static void diag_uart_send_uint32(uint32_t value)
{
    char buf[12];
    int i = 0;
    if (value == 0) {
        diag_uart_send_char('0');
        return;
    }
    while (value > 0 && i < 10) {
        buf[i++] = '0' + (value % 10);
        value /= 10;
    }
    for (int j = i - 1; j >= 0; j--) {
        diag_uart_send_char(buf[j]);
    }
}

static bool diag_uart_rx_ready(void)
{
    return (USART2_SR & USART_SR_RXNE) != 0;
}

static char diag_uart_recv_char(void)
{
    while (!(USART2_SR & USART_SR_RXNE))
        ;
    return (char)(USART2_DR & 0xFF);
}

/* ============================================================
 * Utility: Parse hex string to uint32
 * ============================================================ */

static bool parse_hex(const char *str, uint32_t *out)
{
    if (!str || !out) return false;

    uint32_t result = 0;
    const char *p = str;

    /* Skip optional 0x prefix */
    if (p[0] == '0' && (p[1] == 'x' || p[1] == 'X')) {
        p += 2;
    }

    if (*p == '\0') return false;

    int count = 0;
    while (*p && count < 8) {
        char c = *p++;
        uint8_t nibble;
        if (c >= '0' && c <= '9')      nibble = c - '0';
        else if (c >= 'a' && c <= 'f') nibble = c - 'a' + 10;
        else if (c >= 'A' && c <= 'F') nibble = c - 'A' + 10;
        else return false;

        result = (result << 4) | nibble;
        count++;
    }

    *out = result;
    return true;
}

static bool parse_uint(const char *str, uint32_t *out)
{
    if (!str || !out) return false;

    /* Try hex first */
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        return parse_hex(str, out);
    }

    /* Decimal */
    uint32_t result = 0;
    const char *p = str;
    while (*p) {
        if (*p < '0' || *p > '9') return false;
        uint32_t prev = result;
        result = result * 10 + (*p - '0');
        if (result < prev) return false; /* overflow */
        p++;
    }
    *out = result;
    return true;
}

/* ============================================================
 * Timing-Safe String Comparison (anti-timing-attack for auth)
 * ============================================================ */

static bool secure_compare(const uint8_t *a, const uint8_t *b, size_t len)
{
    volatile uint8_t result = 0;
    for (size_t i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }
    return result == 0;
}

/* ============================================================
 * Session & Authentication Management
 * ============================================================ */

/*
 * IMPORTANT: In production, replace this with a proper authentication mechanism:
 * - Per-device unique passwords derived from device serial + master key
 * - Challenge-response authentication
 * - Time-based one-time passwords (TOTP)
 * - Certificate-based authentication
 * 
 * The hardcoded password below is a PLACEHOLDER for demonstration only.
 * Your build system should inject a unique per-device credential.
 */

/* This should be stored in protected flash, derived per-device */
static const uint8_t DIAG_AUTH_HASH[] = {
    /* SHA-256 of device-specific diagnostic password */
    /* PLACEHOLDER - replace with actual hash in production build system */
    0xEF, 0x92, 0xB7, 0x78, 0xBA, 0xFE, 0x77, 0x1E,
    0x89, 0x24, 0x5D, 0x5C, 0xD6, 0x7B, 0x7A, 0x21,
    0x88, 0xA7, 0x55, 0xC8, 0xB7, 0x95, 0x53, 0x8B,
    0x42, 0x16, 0xAE, 0x8E, 0x22, 0xF1, 0xF0, 0x55
};

/* Minimal hash for demo - REPLACE with proper SHA-256 in production */
static void simple_hash(const char *input, uint8_t *output, size_t out_len)
{
    /*
     * WARNING: This is NOT a cryptographic hash. It's a placeholder.
     * Use mbedTLS SHA-256, hardware crypto accelerator, or similar
     * in your actual firmware.
     */
    memset(output, 0, out_len);
    size_t in_len = strlen(input);
    for (size_t i = 0; i < in_len; i++) {
        output[i % out_len] ^= (uint8_t)input[i];
        output[(i + 1) % out_len] ^= (uint8_t)(input[i] << 3);
        output[(i + 2) % out_len] += (uint8_t)(input[i] >> 2);
        /* Rotate */
        for (size_t j = 0; j < out_len - 1; j++) {
            output[j] ^= output[j + 1] >> 5;
            output[j + 1] ^= output[j] << 3;
        }
    }
}

static void diag_session_init(void)
{
    memset(&g_session, 0, sizeof(g_session));
    g_session.state = AUTH_STATE_LOCKED;
    g_session.failed_attempts = 0;
    g_session.jtag_enabled_this_session = false;
}

static bool diag_session_is_authenticated(void)
{
#if !DIAG_AUTH_REQUIRED
    return true;
#endif
    return g_session.state == AUTH_STATE_AUTHENTICATED;
}

static void diag_session_update_activity(void)
{
    g_session.last_activity_tick = get_tick_sec();
}

static void diag_session_check_timeout(void)
{
    if (g_session.state != AUTH_STATE_AUTHENTICATED) return;

    uint32_t now = get_tick_sec();
    if ((now - g_session.last_activity_tick) > DIAG_SESSION_TIMEOUT_SEC) {
        g_session.state = AUTH_STATE_LOCKED;
        diag_print_line("\n[SECURITY] Session timed out. Re-authentication required.");

        /* Disable JTAG if it was enabled during this session */
        if (g_session.jtag_enabled_this_session) {
            /* Disable JTAG pins */
            DBGMCU_CR = 0;
            g_session.jtag_enabled_this_session = false;
            diag_print_line("[SECURITY] JTAG disabled on session timeout.");
        }

        diag_audit_log_entry("SESSION_TIMEOUT", 0);
    }
}

static bool diag_check_lockout(void)
{
    if (g_session.state != AUTH_STATE_LOCKED_OUT) return false;

    uint32_t now = get_tick_sec();
    if ((now - g_session.lockout_start_tick) > DIAG_LOCKOUT_DURATION_SEC) {
        g_session.state = AUTH_STATE_LOCKED;
        g_session.failed_attempts = 0;
        diag_print_line("[INFO] Lockout period expired. Authentication available.");
        return false;
    }

    return true; /* Still locked out */
}

static bool diag_authenticate(const char *password)
{
    if (diag_check_lockout()) {
        uint32_t remaining = DIAG_LOCKOUT_DURATION_SEC -
                             (get_tick_sec() - g_session.lockout_start_tick);
        diag_uart_send_string("[DENIED] Account locked. Try again in ");
        diag_uart_send_uint32(remaining);
        diag_print_line(" seconds.");
        return false;
    }

    uint8_t input_hash[32];
    simple_hash(password, input_hash, sizeof(input_hash));

    if (secure_compare(input_hash, DIAG_AUTH_HASH, sizeof(DIAG_AUTH_HASH))) {
        g_session.state = AUTH_STATE_AUTHENTICATED;
        g_session.failed_attempts = 0;
        g_session.last_activity_tick = get_tick_sec();
        diag_print_line("[OK] Authenticated. Session active.");
        diag_uart_send_string("[INFO] Session timeout: ");
        diag_uart_send_uint32(DIAG_SESSION_TIMEOUT_SEC);
        diag_print_line(" seconds.");
        diag_audit_log_entry("AUTH_SUCCESS", 0);

        /* Clear hash from stack */
        memset(input_hash, 0, sizeof(input_hash));
        return true;
    }

    /* Clear hash from stack */
    memset(input_hash, 0, sizeof(input_hash));

    g_session.failed_attempts++;
    diag_uart_send_string("[DENIED] Authentication failed. Attempts: ");
    diag_uart_send_uint32(g_session.failed_attempts);
    diag_uart_send_char('/');
    diag_uart_send_uint32(DIAG_MAX_AUTH_FAILURES);
    diag_print_line("");

    diag_audit_log_entry("AUTH_FAILURE", 1);

    if (g_session.failed_attempts >= DIAG_MAX_AUTH_FAILURES) {
        g_session.state = AUTH_STATE_LOCKED_OUT;
        g_session.lockout_start_tick = get_tick_sec();
        diag_uart_send_string("[SECURITY] Max attempts exceeded. Locked for ");
        diag_uart_send_uint32(DIAG_LOCKOUT_DURATION_SEC);
        diag_print_line(" seconds.");
        diag_audit_log_entry("AUTH_LOCKOUT", 1);
    }

    return false;
}

/* ============================================================
 * Audit Logging
 * ============================================================ */

static void diag_audit_log_entry(const char *cmd, uint8_t result)
{
#if !DIAG_AUDIT_LOG_ENABLED
    return;
#endif

    uint32_t idx = g_audit_log.write_index % AUDIT_LOG_MAX_ENTRIES;
    audit_entry_t *entry = &g_audit_log.entries[idx];

    entry->timestamp = get_tick_sec();
    strncpy((char *)entry->command, cmd, AUDIT_CMD_MAX_LEN - 1);
    entry->command[AUDIT_CMD_MAX_LEN - 1] = '\0';
    entry->result = result;
    entry->auth_state = (uint8_t)g_session.state;

    g_audit_log.write_index++;
    g_audit_log.total_entries++;
}

/* ============================================================
 * Memory Access Validation
 * ============================================================ */

static bool diag_is_address_safe(uint32_t addr, uint32_t len, bool for_dump)
{
#if !DIAG_RESTRICT_MEMORY_ACCESS
    /* If restriction is disabled, still block known secret areas */
    for (uint32_t i = 0; i < BLOCKED_REGION_COUNT; i++) {
        if (addr >= blocked_memory_regions[i].start &&
            (addr + len - 1) <= blocked_memory_regions[i].end) {
            return false;
        }
        /* Check for overlap */
        if (addr < blocked_memory_regions[i].end &&
            (addr + len) > blocked_memory_regions[i].start) {
            return false;
        }
    }
    return true;
#endif

    /* Check that the ENTIRE range falls within a single safe region */
    uint32_t end_addr = addr + len - 1;

    /* First check blocked regions */
    for (uint32_t i = 0; i < BLOCKED_REGION_COUNT; i++) {
        if (addr < blocked_memory_regions[i].end &&
            (addr + len) > blocked_memory_regions[i].start) {
            return false;
        }
    }

    /* Then verify within an allowed region */
    for (uint32_t i = 0; i < SAFE_REGION_COUNT; i++) {
        if (addr >= safe_memory_regions[i].start &&
            end_addr <= safe_memory_regions[i].end) {
            if (for_dump) return safe_memory_regions[i].allow_dump;
            return safe_memory_regions[i].allow_read;
        }
    }

    return false;
}

/* ============================================================
 * JTAG Control Functions
 * ============================================================ */

static bool diag_jtag_is_enabled(void)
{
    /* Check DBGMCU_CR for trace/debug enabled flags */
    return (DBGMCU_CR & 0x07) != 0;
}

static void diag_jtag_set_enabled(bool enable)
{
    if (enable) {
        /* Configure JTAG pins (PA13=SWDIO, PA14=SWCLK, PB3=SWO) */
        /* These are default alternate function on reset */
        /* Enable debug in sleep/stop/standby modes */
        DBGMCU_CR |= (1U << 0) | (1U << 1) | (1U << 2);

        /* PA13, PA14 - alternate function (should be default) */
        /* Leave pin configuration as reset default for SWD */
    } else {
        /* Disable debug features */
        DBGMCU_CR &= ~((1U << 0) | (1U << 1) | (1U << 2));

        /* Optionally reconfigure JTAG pins as GPIO to prevent probing */
        /* PA13 = GPIO output low, PA14 = GPIO output low */
        GPIOA_MODER &= ~((3U << (13 * 2)) | (3U << (14 * 2)));
        GPIOA_MODER |=  ((1U << (13 * 2)) | (1U << (14 * 2)));
    }
}

/* ============================================================
 * Command Handlers
 * ============================================================ */

static void cmd_help(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_print_line("=== Industrial IoT Sensor Diagnostic Console ===");
    diag_print_line("Available commands:");
    diag_print_line("");

    for (uint32_t i = 0; i < DIAG_CMD_COUNT; i++) {
        if (diag_commands[i].requires_auth && !diag_session_is_authenticated()) {
            continue; /* Don't show restricted commands to unauthenticated users */
        }
        diag_uart_send_string("  ");
        diag_uart_send_string(diag_commands[i].name);

        /* Pad to column */
        int pad = 16 - (int)strlen(diag_commands[i].name);
        while (pad-- > 0) diag_uart_send_char(' ');

        diag_print_line(diag_commands[i].help);
    }

    if (!diag_session_is_authenticated()) {
        diag_print_line("");
        diag_print_line("[INFO] Additional commands available after authentication.");
        diag_print_line("       Use 'auth <password>' to authenticate.");
    }
}

static void cmd_auth(int argc, char *argv[])
{
    if (argc < 2) {
        diag_print_line("Usage: auth <password>");
        return;
    }

    if (diag_session_is_authenticated()) {
        diag_print_line("[INFO] Already authenticated.");
        return;
    }

    diag_authenticate(argv[1]);

    /* Overwrite password in buffer to minimize exposure */
    memset(argv[1], 0, strlen(argv[1]));
}

static void cmd_logout(int argc, char *argv[])
{
    (void)argc; (void)argv;

    if (g_session.jtag_enabled_this_session) {
        diag_jtag_set_enabled(false);
        g_session.jtag_enabled_this_session = false;
        diag_print_line("[INFO] JTAG disabled.");
    }

    g_session.state = AUTH_STATE_LOCKED;
    diag_print_line("[OK] Logged out. Session ended.");
    diag_audit_log_entry("LOGOUT", 0);
}

static void cmd_status(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_print_line("=== Device Status ===");

    diag_uart_send_string("Auth State:     ");
    switch (g_session.state) {
        case AUTH_STATE_LOCKED:        diag_print_line("LOCKED"); break;
        case AUTH_STATE_AUTHENTICATED: diag_print_line("AUTHENTICATED"); break;
        case AUTH_STATE_LOCKED_OUT:    diag_print_line("LOCKED OUT"); break;
    }

    diag_uart_send_string("Uptime:         ");
    diag_uart_send_uint32(get_tick_sec());
    diag_print_line(" seconds");

    diag_uart_send_string("JTAG Status:    ");
    diag_print_line(diag_jtag_is_enabled() ? "ENABLED" : "DISABLED");

    diag_uart_send_string("JTAG Allowed:   ");
    diag_print_line(DIAG_JTAG_ALLOW_ENABLE ? "YES" : "NO (production lock)");

    diag_uart_send_string("Audit Entries:  ");
    diag_uart_send_uint32(g_audit_log.total_entries);
    diag_print_line("");

    diag_uart_send_string("Failed Auth:    ");
    diag_uart_send_uint32(g_session.failed_attempts);
    diag_uart_send_char('/');
    diag_uart_send_uint32(DIAG_MAX_AUTH_FAILURES);
    diag_print_line("");
}

static void cmd_version(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_print_line("=== Firmware Info ===");
    diag_print_line("Product:    Industrial IoT Sensor");
    diag_print_line("FW Version: 2.4.1");
    diag_print_line("Build Date: " __DATE__ " " __TIME__);
    diag_print_line("HW Rev:     Rev C");
    diag_print_line("Diag Ver:   1.0.0-secure");
}

static void cmd_dump_memory(int argc, char *argv[])
{
    uint32_t addr, len = 256;

    if (!parse_hex(argv[1], &addr)) {
        diag_print_line("[ERROR] Invalid address. Use hex format: 0x20000000");
        return;
    }

    if (argc >= 3) {
        if (!parse_uint(argv[2], &len)) {
            diag_print_line("[ERROR] Invalid length.");
            return;
        }
    }

    /* Limit maximum dump size */
    if (len > 4096) {
        diag_print_line("[ERROR] Maximum dump size is 4096 bytes.");
        return;
    }

    /* Validate address range */
    if (!diag_is_address_safe(addr, len, true)) {
        diag_print_line("[DENIED] Address range not accessible.");
        diag_print_line("         Use 'regions' to see permitted memory ranges.");
        diag_audit_log_entry("dump_memory DENIED", 1);
        return;
    }

    diag_audit_log_entry("dump_memory", 0);

    diag_uart_send_string("Memory dump at 0x");
    diag_uart_send_hex(addr, 8);
    diag_uart_send_string(", ");
    diag_uart_send_uint32(len);
    diag_print_line(" bytes:");
    diag_print_line("----------------------------------------------------");

    volatile uint8_t *ptr = (volatile uint8_t *)addr;

    for (uint32_t i = 0; i < len; i += 16) {
        /* Address */
        diag_uart_send_string("0x");
        diag_uart_send_hex(addr + i, 8);
        diag_uart_send_string(": ");

        /* Hex bytes */
        uint32_t row_len = (len - i < 16) ? (len - i) : 16;
        for (uint32_t j = 0; j < row_len; j++) {
            diag_uart_send_hex8(ptr[i + j]);
            diag_uart_send_char(' ');
            if (j == 7) diag_uart_send_char(' ');
        }

        /* Pad if short row */
        for (uint32_t j = row_len; j < 16; j++) {
            diag_uart_send_string("   ");
            if (j == 7) diag_uart_send_char(' ');
        }

        diag_uart_send_string(" |");

        /* ASCII */
        for (uint32_t j = 0; j < row_len; j++) {
            char c = (char)ptr[i + j];
            diag_uart_send_char((c >= 0x20 && c <= 0x7E) ? c : '.');
        }

        diag_uart_send_char('|');
        diag_uart_send_string("\r\n");
    }

    diag_print_line("----------------------------------------------------");
}

static void cmd_read_flash(int argc, char *argv[])
{
    uint32_t offset, len = 256;

    if (!parse_hex(argv[1], &offset)) {
        diag_print_line("[ERROR] Invalid offset. Use hex format: 0x1000");
        return;
    }

    if (argc >= 3) {
        if (!parse_uint(argv[2], &len)) {
            diag_print_line("[ERROR] Invalid length.");
            return;
        }
    }

    uint32_t addr = FLASH_BASE_ADDR + offset;

    /* Validate within flash bounds */
    if (offset + len > FLASH_SIZE) {
        diag_print_line("[ERROR] Offset + length exceeds flash size.");
        return;
    }

    /* Limit maximum read size */
    if (len > 4096) {
        diag_print_line("[ERROR] Maximum read size is 4096 bytes.");
        return;
    }

    if (!diag_is_address_safe(addr, len, true)) {
        diag_print_line("[DENIED] Flash region not accessible.");
        diag_print_line("         Use 'regions' to see permitted memory ranges.");
        diag_audit_log_entry("read_flash DENIED", 1);
        return;
    }

    diag_audit_log_entry("read_flash", 0);

    diag_uart_send_string("Flash read at offset 0x");
    diag_uart_send_hex(offset, 8);
    diag_uart_send_string(" (addr 0x");
    diag_uart_send_hex(addr, 8);
    diag_uart_send_string("), ");
    diag_uart_send_uint32(len);
    diag_print_line(" bytes:");

    /* Reuse memory dump format */
    volatile uint8_t *ptr = (volatile uint8_t *)addr;
    for (uint32_t i = 0; i < len; i += 16) {
        diag_uart_send_string("0x");
        diag_uart_send_hex(addr + i, 8);
        diag_uart_send_string(": ");

        uint32_t row_len = (len - i < 16) ? (len - i) : 16;
        for (uint32_t j = 0; j < row_len; j++) {
            diag_uart_send_hex8(ptr[i + j]);
            diag_uart_send_char(' ');
        }
        diag_uart_send_string("\r\n");
    }
}

static void cmd_get_config(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_audit_log_entry("get_config", 0);

    diag_print_line("=== Device Configuration ===");
    diag_print_line("Device ID:       IIOT-SENSOR-001");
    diag_print_line("Serial:          SN-2024-00042");

    /* Read actual config from flash/EEPROM - example values */
    diag_print_line("--- Sensor Config ---");
    diag_print_line("Sample Rate:     100 Hz");
    diag_print_line("Averaging:       16 samples");
    diag_print_line("Sensor Type:     Pressure/Temperature");
    diag_print_line("Calibration:     2024-01-15");

    diag_print_line("--- Communication ---");
    diag_print_line("Protocol:        MQTT");
    diag_print_line("Broker:          mqtt.factory-floor.local");
    diag_print_line("Port:            8883 (TLS)");
    diag_print_line("Topic:           sensors/pressure/zone3");
    diag_print_line("Report Interval: 5 seconds");

    diag_print_line("--- Security ---");
    diag_print_line("TLS:             Enabled (TLS 1.3)");
    diag_print_line("Client Cert:     Installed");
    /* NOTE: Never print keys or certificates via diagnostic console */
    diag_print_line("Credentials:     [REDACTED - use secure provisioning]");

    diag_print_line("--- Power ---");
    diag_print_line("Mode:            Continuous");
    diag_print_line("Watchdog:        Enabled (8s timeout)");
}

static void cmd_get_sensors(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_audit_log_entry("get_sensors", 0);

    /* Read actual sensor values - placeholder implementation */
    diag_print_line("=== Sensor Readings ===");

    diag_uart_send_string("Temperature:     ");
    diag_uart_send_uint32(23);
    diag_print_line(".4 °C");

    diag_uart_send_string("Pressure:        ");
    diag_uart_send_uint32(1013);
    diag_print_line(".25 hPa");

    diag_uart_send_string("Humidity:        ");
    diag_uart_send_uint32(45);
    diag_print_line(".2 %RH");

    diag_uart_send_string("ADC Raw Ch0:     0x");
    diag_uart_send_hex(0x0A3F, 4);
    diag_print_line("");

    diag_uart_send_string("ADC Raw Ch1:     0x");
    diag_uart_send_hex(0x0B12, 4);
    diag_print_line("");

    diag_print_line("Sensor Health:   OK");
    diag_print_line("Last Cal Check:  PASS");
}

static void cmd_get_network(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_audit_log_entry("get_network", 0);

    diag_print_line("=== Network Status ===");
    diag_print_line("Interface:       Ethernet (W5500)");
    diag_print_line("Link:            UP");
    diag_print_line("Speed:           100 Mbps Full Duplex");
    diag_print_line("MAC:             02:AA:BB:CC:DD:EE");
    diag_print_line("IP:              192.168.1.42");
    diag_print_line("Netmask:         255.255.255.0");
    diag_print_line("Gateway:         192.168.1.1");
    diag_print_line("DNS:             192.168.1.1");
    diag_print_line("MQTT Connected:  YES");
    diag_uart_send_string("MQTT Msgs Sent:  ");
    diag_uart_send_uint32(15432);
    diag_print_line("");
    diag_uart_send_string("MQTT Errors:     ");
    diag_uart_send_uint32(3);
    diag_print_line("");
    diag_print_line("Last MQTT Error: Timeout (12:34:56)");
}

static void cmd_get_uptime(int argc, char *argv[])
{
    (void)argc; (void)argv;

    uint32_t total_sec = get_tick_sec();
    uint32_t days = total_sec / 86400;
    uint32_t hours = (total_sec % 86400) / 3600;
    uint32_t mins = (total_sec % 3600) / 60;
    uint32_t secs = total_sec % 60;

    diag_uart_send_string("Uptime: ");
    diag_uart_send_uint32(days);
    diag_uart_send_string("d ");
    diag_uart_send_uint32(hours);
    diag_uart_send_string("h ");
    diag_uart_send_uint32(mins);
    diag_uart_send_string("m ");
    diag_uart_send_uint32(secs);
    diag_print_line("s");

    diag_uart_send_string("Total seconds: ");
    diag_uart_send_uint32(total_sec);
    diag_print_line("");

    diag_uart_send_string("Boot count: ");
    diag_uart_send_uint32(1); /* Read from persistent storage */
    diag_print_line("");

    diag_print_line("Last reset: Power-on Reset");
}

static void cmd_jtag_status(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_print_line("=== JTAG/SWD Status ===");

    diag_uart_send_string("Debug Port:    ");
    diag_print_line(diag_jtag_is_enabled() ? "ENABLED" : "DISABLED");

    diag_uart_send_string("Policy:        ");
#if DIAG_JTAG_ALLOW_ENABLE
    diag_print_line("Runtime enable/disable ALLOWED");
#else
    diag_print_line("PERMANENTLY DISABLED (production)");
#endif

    diag_uart_send_string("DBGMCU_CR:     0x");
    diag_uart_send_hex(DBGMCU_CR, 8);
    diag_print_line("");

    diag_audit_log_entry("jtag_status", 0);
}

static void cmd_jtag_enable(int argc, char *argv[])
{
    (void)argc; (void)argv;

#if !DIAG_JTAG_ALLOW_ENABLE
    diag_print_line("[DENIED] JTAG enable is disabled in production firmware.");
    diag_print_line("         This device has permanent JTAG lockdown.");
    diag_audit_log_entry("jtag_enable DENIED (policy)", 1);
    return;
#else
    diag_print_line("[WARNING] Enabling JTAG debug port.");
    diag_print_line("          JTAG will be disabled on logout or session timeout.");

    diag_jtag_set_enabled(true);
    g_session.jtag_enabled_this_session = true;

    diag_print_line("[OK] JTAG/SWD enabled.");
    diag_print_line("     SWDIO=PA13, SWCLK=PA14, SWO=PB3");
    diag_audit_log_entry("jtag_enable", 0);
#endif
}

static void cmd_jtag_disable(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_jtag_set_enabled(false);
    g_session.jtag_enabled_this_session = false;

    diag_print_line("[OK] JTAG/SWD disabled.");
    diag_audit_log_entry("jtag_disable", 0);
}

static void cmd_audit_show(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_print_line("=== Diagnostic Audit Log ===");

    diag_uart_send_string("Total entries logged: ");
    diag_uart_send_uint32(g_audit_log.total_entries);
    diag_print_line("");

    uint32_t count = g_audit_log.total_entries;
    if (count > AUDIT_LOG_MAX_ENTRIES) count = AUDIT_LOG_MAX_ENTRIES;

    if (count == 0) {
        diag_print_line("(no entries)");
        return;
    }

    diag_print_line("Time(s)    Result  Command");
    diag_print_line("---------- ------- --------------------------------");

    /* Show most recent entries (up to 20) */
    uint32_t start = 0;
    uint32_t show_count = count;
    if (show_count > 20) {
        start = show_count - 20;
        show_count = 20;
    }

    for (uint32_t i = start; i < start + show_count; i++) {
        uint32_t idx = i % AUDIT_LOG_MAX_ENTRIES;
        audit_entry_t *e = &g_audit_log.entries[idx];

        /* Timestamp */
        diag_uart_send_uint32(e->timestamp);
        int tpad = 11 - 1; /* rough padding */
        while (tpad-- > 0) diag_uart_send_char(' ');

        /* Result */
        switch (e->result) {
            case 0:  diag_uart_send_string("OK      "); break;
            case 1:  diag_uart_send_string("DENIED  "); break;
            case 2:  diag_uart_send_string("ERROR   "); break;
            default: diag_uart_send_string("???     "); break;
        }

        /* Command */
        diag_print_line((const char *)e->command);
    }

    diag_audit_log_entry("audit_show", 0);
}

static void cmd_regions(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_print_line("=== Accessible Memory Regions ===");
    diag_print_line("Start      End        Name            Read  Dump");
    diag_print_line("---------- ---------- --------------- ----- -----");

    for (uint32_t i = 0; i < SAFE_REGION_COUNT; i++) {
        diag_uart_send_string("0x");
        diag_uart_send_hex(safe_memory_regions[i].start, 8);
        diag_uart_send_string(" 0x");
        diag_uart_send_hex(safe_memory_regions[i].end, 8);
        diag_uart_send_char(' ');

        diag_uart_send_string(safe_memory_regions[i].name);
        int pad = 16 - (int)strlen(safe_memory_regions[i].name);
        while (pad-- > 0) diag_uart_send_char(' ');

        diag_uart_send_string(safe_memory_regions[i].allow_read ? "YES   " : "NO    ");
        diag_print_line(safe_memory_regions[i].allow_dump ? "YES" : "NO");
    }

    diag_print_line("");
    diag_print_line("=== Blocked Memory Regions (always denied) ===");
    for (uint32_t i = 0; i < BLOCKED_REGION_COUNT; i++) {
        diag_uart_send_string("0x");
        diag_uart_send_hex(blocked_memory_regions[i].start, 8);
        diag_uart_send_string(" 0x");
        diag_uart_send_hex(blocked_memory_regions[i].end, 8);
        diag_uart_send_char(' ');
        diag_print_line(blocked_memory_regions[i].name);
    }
}

static void cmd_reboot(int argc, char *argv[])
{
    (void)argc; (void)argv;

    diag_audit_log_entry("reboot", 0);

    /* Disable JTAG before reboot */
    if (g_session.jtag_enabled_this_session) {
        diag_jtag_set_enabled(false);
    }

    diag_print_line("[INFO] Rebooting device...");

    /* Wait for UART to finish transmitting */
    while (!(USART2_SR & USART_SR_TC))
        ;

    /* ARM NVIC System Reset */
    #define AIRCR (*(volatile uint32_t *)0xE000ED0CUL)
    AIRCR = 0x05FA0004UL;

    /* Should not reach here */
    while (1) { }
}

/* ============================================================
 * Command Parser
 * ============================================================ */

static void diag_parse_and_execute(char *cmd_line)
{
    char *argv[DIAG_MAX_ARGS];
    int argc = 0;

    /* Skip leading whitespace */
    while (*cmd_line == ' ' || *cmd_line == '\t') cmd_line++;

    /* Empty line */
    if (*cmd_line == '\0') return;

    /* Tokenize */
    char *token = cmd_line;
    bool in_token = false;

    for (char *p = cmd_line; ; p++) {
        if (*p == ' ' || *p == '\t' || *p == '\0') {
            bool end = (*p == '\0');
            if (in_token) {
                *p = '\0';
                if (argc < DIAG_MAX_ARGS) {
                    argv[argc++] = token;
                }
                in_token = false;
            }
            if (end) break;
        } else {
            if (!in_token) {
                token = p;
                in_token = true;
            }
        }
    }

    if (argc == 0) return;

    /* Find and execute command */
    for (uint32_t i = 0; i < DIAG_CMD_COUNT; i++) {
        if (strcmp(argv[0], diag_commands[i].name) == 0) {

            /* Check authentication requirement */
            if (diag_commands[i].requires_auth && !diag_session_is_authenticated()) {
                diag_print_line("[DENIED] Authentication required. Use 'auth <password>'.");
                diag_audit_log_entry(argv[0], 1);
                return;
            }

            /* Check minimum arguments */
            if ((uint8_t)(argc - 1) < diag_commands[i].min_args) {
                diag_uart_send_string("[ERROR] Not enough arguments. Usage: ");
                diag_print_line(diag_commands[i].help);
                return;
            }

            /* Update session activity */
            if (diag_session_is_authenticated()) {
                diag_session_update_activity();
            }

            /* Execute */
            diag_commands[i].handler(argc, argv);
            return;
        }
    }

    diag_uart_send_string("[ERROR] Unknown command: '");
    diag_uart_send_string(argv[0]);
    diag_print_line("'. Type 'help' for available commands.");
}

/* ============================================================
 * Main Console Interface
 * ============================================================ */

void diag_console_init(void)
{
#if !DIAG_ENABLED
    return;
#endif

    /* Initialize UART */
    diag_uart_init();

    /* Initialize session (locked by default) */
    diag_session_init();

    /* Clear audit log */
    memset(&g_audit_log, 0, sizeof(g_audit_log));

    /* Disable JTAG by default in production */
#if !DIAG_JTAG_ALLOW_ENABLE
    diag_jtag_set_enabled(false);
#endif

    /* Clear command buffer */
    memset(g_cmd_buffer, 0, sizeof(g_cmd_buffer));
    g_cmd_index = 0;

    g_console_initialized = true;

    /* Print banner */
    diag_print_line("");
    diag_print_line("=============================================");
    diag_print_line("  Industrial IoT Sensor - Diagnostic Console");
    diag_print_line("  FW v2.4.1 | Secure Diag v1.0.0");
    diag_print_line("=============================================");
    diag_print_line("WARNING: Authorized access only.");
    diag_print_line("All commands are logged and audited.");
    diag_print_line("Type 'help' for available commands.");
    diag_print_line("Type 'auth <password>' to authenticate.");
    diag_print_line("");

    diag_audit_log_entry("CONSOLE_INIT", 0);

    /* Print prompt */
    diag_uart_send_string(DIAG_LOCKED_PROMPT);
}

/*
 * Call this from your main loop or a dedicated task.
 * Non-blocking: returns immediately if no data available.
 */
void diag_console_process(void)
{
#if !DIAG_ENABLED
    return;
#endif

    if (!g_console_initialized) return;

    /* Check session timeout */
    diag_session_check_timeout();

    /* Check for incoming character */
    if (!diag_uart_rx_ready()) return;

    char c = diag_uart_recv_char();

    /* Handle special characters */
    switch (c) {
        case '\r':
        case '\n':
            diag_uart_send_string("\r\n");
            g_cmd_buffer[g_cmd_index] = '\0';

            if (g_cmd_index > 0) {
                diag_parse_and_execute(g_cmd_buffer);
            }

            /* Reset buffer and show prompt */
            g_cmd_index = 0;
            memset(g_cmd_buffer, 0, sizeof(g_cmd_buffer));

            if (diag_session_is_authenticated()) {
                diag_uart_send_string(DIAG_PROMPT);
            } else {
                diag_uart_send_string(DIAG_LOCKED_PROMPT);
            }
            break;

        case '\b':
        case 0x7F: /* DEL */
            if (g_cmd_index > 0) {
                g_cmd_index--;
                diag_uart_send_string("\b \b");
            }
            break;

        case 0x03: /* Ctrl+C */
            diag_print_line("^C");
            g_cmd_index = 0;
            memset(g_cmd_buffer, 0, sizeof(g_cmd_buffer));
            if (diag_session_is_authenticated()) {
                diag_uart_send_string(DIAG_PROMPT);
            } else {
                diag_uart_send_string(DIAG_LOCKED_PROMPT);
            }
            break;

        default:
            /* Only accept printable characters */
            if (c >= 0x20 && c <= 0x7E) {
                if (g_cmd_index < DIAG_CMD_BUFFER_SIZE - 1) {
                    g_cmd_buffer[g_cmd_index++] = c;
                    diag_uart_send_char(c);
                }
            }
            break;
    }
}

/* ============================================================
 * Integration Example - Main Application
 * ============================================================ */

/*
 * Example main() showing how to integrate the diagnostic console
 * with your IoT sensor firmware.
 */

#if 0 /* Enable for standalone build/test */

/* Your application-specific includes and init here */
extern void app_sensor_init(void);
extern void app_sensor_process(void);
extern void app_network