# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_PATH_SIZE 256
#define MAX_HEADERS 32
#define MAX_HEADER_SIZE 512

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_HEAD,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[384];
} http_header_t;

typedef struct {
    http_method_t method;
    char path[MAX_PATH_SIZE];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_request;
    size_t raw_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_response;
    size_t raw_length;
} http_response_t;

typedef struct {
    unsigned long total_requests;
    unsigned long successful_requests;
    unsigned long failed_requests;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    double total_processing_time_ms;
} server_stats_t;

static server_stats_t g_stats = {0};

/* Simulated incoming requests for demonstration */
static const char *simulated_requests[] = {
    "GET / HTTP/1.1\r\nHost: localhost\r\nConnection: keep-alive\r\n\r\n",
    "GET /api/status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"key\":\"value\",\"count\":42}",
    "GET /static/style.css HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "DELETE /api/data/5 HTTP/1.1\r\nHost: localhost\r\nAuthorization: Bearer token123\r\n\r\n",
    "PUT /api/data/3 HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 20\r\n\r\n{\"updated\":\"true\"}",
    "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "GET /api/stats HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    NULL
};

static http_method_t parse_method(const char *method_str) {
    if (strcmp(method_str, "GET") == 0) return HTTP_GET;
    if (strcmp(method_str, "POST") == 0) return HTTP_POST;
    if (strcmp(method_str, "PUT") == 0) return HTTP_PUT;
    if (strcmp(method_str, "DELETE") == 0) return HTTP_DELETE;
    if (strcmp(method_str, "HEAD") == 0) return HTTP_HEAD;
    return HTTP_UNKNOWN;
}

static const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        case HTTP_HEAD: return "HEAD";
        default: return "UNKNOWN";
    }
}

static http_request_t *allocate_request(void) {
    http_request_t *req = (http_request_t *)malloc(sizeof(http_request_t));
    if (!req) {
        fprintf(stderr, "ERROR: Failed to allocate request structure\n");
        return NULL;
    }
    memset(req, 0, sizeof(http_request_t));

    req->raw_request = (char *)malloc(MAX_REQUEST_SIZE);
    if (!req->raw_request) {
        fprintf(stderr, "ERROR: Failed to allocate request buffer\n");
        free(req);
        return NULL;
    }
    memset(req->raw_request, 0, MAX_REQUEST_SIZE);

    return req;
}

static void free_request(http_request_t *req) {
    if (req) {
        if (req->raw_request) {
            free(req->raw_request);
            req->raw_request = NULL;
        }
        if (req->body) {
            free(req->body);
            req->body = NULL;
        }
        free(req);
    }
}

static http_response_t *allocate_response(void) {
    http_response_t *resp = (http_response_t *)malloc(sizeof(http_response_t));
    if (!resp) {
        fprintf(stderr, "ERROR: Failed to allocate response structure\n");
        return NULL;
    }
    memset(resp, 0, sizeof(http_response_t));

    resp->raw_response = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!resp->raw_response) {
        fprintf(stderr, "ERROR: Failed to allocate response buffer\n");
        free(resp);
        return NULL;
    }
    memset(resp->raw_response, 0, MAX_RESPONSE_SIZE);

    return resp;
}

static void free_response(http_response_t *resp) {
    if (resp) {
        if (resp->raw_response) {
            free(resp->raw_response);
            resp->raw_response = NULL;
        }
        if (resp->body) {
            free(resp->body);
            resp->body = NULL;
        }
        free(resp);
    }
}

static int parse_request(http_request_t *req, const char *raw_data, size_t data_len) {
    if (!req || !raw_data || data_len == 0) {
        return -1;
    }

    if (data_len >= MAX_REQUEST_SIZE) {
        fprintf(stderr, "ERROR: Request too large (%zu bytes)\n", data_len);
        return -1;
    }

    memcpy(req->raw_request, raw_data, data_len);
    req->raw_request[data_len] = '\0';
    req->raw_length = data_len;

    /* Parse request line */
    char *work_buf = (char *)malloc(data_len + 1);
    if (!work_buf) {
        return -1;
    }
    memcpy(work_buf, raw_data, data_len);
    work_buf[data_len] = '\0';

    /* Find end of request line */
    char *line_end = strstr(work_buf, "\r\n");
    if (!line_end) {
        free(work_buf);
        return -1;
    }
    *line_end = '\0';

    /* Parse method */
    char *token = strtok(work_buf, " ");
    if (!token) {
        free(work_buf);
        return -1;
    }
    req->method = parse_method(token);

    /* Parse path */
    token = strtok(NULL, " ");
    if (!token) {
        free(work_buf);
        return -1;
    }
    strncpy(req->path, token, MAX_PATH_SIZE - 1);
    req->path[MAX_PATH_SIZE - 1] = '\0';

    /* Parse version */
    token = strtok(NULL, " ");
    if (!token) {
        free(work_buf);
        return -1;
    }
    strncpy(req->version, token, sizeof(req->version) - 1);

    free(work_buf);

    /* Parse headers - work with a fresh copy */
    const char *header_start = strstr(raw_data, "\r\n");
    if (header_start) {
        header_start += 2; /* Skip past \r\n */
        req->header_count = 0;

        while (header_start && *header_start != '\0' && req->header_count < MAX_HEADERS) {
            const char *header_end = strstr(header_start, "\r\n");
            if (!header_end || header_end == header_start) {
                break; /* Empty line = end of headers */
            }

            size_t header_len = header_end - header_start;
            char header_line[MAX_HEADER_SIZE];
            if (header_len >= MAX_HEADER_SIZE) {
                header_start = header_end + 2;
                continue;
            }
            memcpy(header_line, header_start, header_len);
            header_line[header_len] = '\0';

            char *colon = strchr(header_line, ':');
            if (colon) {
                *colon = '\0';
                char *value = colon + 1;
                while (*value == ' ') value++;

                strncpy(req->headers[req->header_count].name, header_line, 127);
                req->headers[req->header_count].name[127] = '\0';
                strncpy(req->headers[req->header_count].value, value, 383);
                req->headers[req->header_count].value[383] = '\0';
                req->header_count++;
            }

            header_start = header_end + 2;
        }
    }

    /* Parse body if present */
    const char *body_start = strstr(raw_data, "\r\n\r\n");
    if (body_start) {
        body_start += 4;
        size_t body_len = data_len - (body_start - raw_data);
        if (body_len > 0) {
            req->body = (char *)malloc(body_len + 1);
            if (req->body) {
                memcpy(req->body, body_start, body_len);
                req->body[body_len] = '\0';
                req->body_length = body_len;
            }
        }
    }

    return 0;
}

static const char *get_request_header(const http_request_t *req, const char *name) {
    for (int i = 0; i < req->header_count; i++) {
        if (strcasecmp(req->headers[i].name, name) == 0) {
            return req->headers[i].value;
        }
    }
    return NULL;
}

static void set_response_header(http_response_t *resp, const char *name, const char *value) {
    if (resp->header_count < MAX_HEADERS) {
        strncpy(resp->headers[resp->header_count].name, name, 127);
        resp->headers[resp->header_count].name[127] = '\0';
        strncpy(resp->headers[resp->header_count].value, value, 383);
        resp->headers[resp->header_count].value[383] = '\0';
        resp->header_count++;
    }
}

static void set_response_body(http_response_t *resp, const char *body) {
    if (resp->body) {
        free(resp->body);
    }
    size_t len = strlen(body);
    resp->body = (char *)malloc(len + 1);
    if (resp->body) {
        memcpy(resp->body, body, len + 1);
        resp->body_length = len;
    }
}

static int build_response(http_response_t *resp) {
    if (!resp || !resp->raw_response) return -1;

    int offset = snprintf(resp->raw_response, MAX_RESPONSE_SIZE,
                          "HTTP/1.1 %d %s\r\n",
                          resp->status_code, resp->status_text);

    for (int i = 0; i < resp->header_count && offset < MAX_RESPONSE_SIZE; i++) {
        offset += snprintf(resp->raw_response + offset, MAX_RESPONSE_SIZE - offset,
                           "%s: %s\r\n",
                           resp->headers[i].name, resp->headers[i].value);
    }

    if (resp->body && resp->body_length > 0 && offset < MAX_RESPONSE_SIZE) {
        char len_str[32];
        snprintf(len_str, sizeof(len_str), "%zu", resp->body_length);
        offset += snprintf(resp->raw_response + offset, MAX_RESPONSE_SIZE - offset,
                           "Content-Length: %s\r\n", len_str);
    }

    if (offset < MAX_RESPONSE_SIZE) {
        offset += snprintf(resp->raw_response + offset, MAX_RESPONSE_SIZE - offset, "\r\n");
    }

    if (resp->body && resp->body_length > 0 && offset + resp->body_length < MAX_RESPONSE_SIZE) {
        memcpy(resp->raw_response + offset, resp->body, resp->body_length);
        offset += resp->body_length;
    }

    resp->raw_length = offset;
    return 0;
}

static void handle_get_root(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strcpy(resp->status_text, "OK");
    set_response_header(resp, "Content-Type", "text/html");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    const char *html =
        "<html><head><title>Embedded Web Server</title></head>"
        "<body><h1>Welcome to Embedded Web Server</h1>"
        "<p>Server is running.</p>"
        "<ul>"
        "<li><a href=\"/api/status\">Server Status</a></li>"
        "<li><a href=\"/api/stats\">Server Statistics</a></li>"
        "</ul></body></html>";
    set_response_body(resp, html);
}

static void handle_get_status(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strcpy(resp->status_text, "OK");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json[512];
    snprintf(json, sizeof(json),
             "{\"status\":\"running\",\"uptime\":\"active\","
             "\"total_requests\":%lu,\"memory\":\"ok\"}",
             g_stats.total_requests);
    set_response_body(resp, json);
}

static void handle_get_stats(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strcpy(resp->status_text, "OK");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json[1024];
    snprintf(json, sizeof(json),
             "{\"total_requests\":%lu,"
             "\"successful_requests\":%lu,"
             "\"failed_requests\":%lu,"
             "\"bytes_received\":%lu,"
             "\"bytes_sent\":%lu,"
             "\"avg_processing_time_ms\":%.3f}",
             g_stats.total_requests,
             g_stats.successful_requests,
             g_stats.failed_requests,
             g_stats.bytes_received,
             g_stats.bytes_sent,
             g_stats.total_requests > 0 ?
                 g_stats.total_processing_time_ms / g_stats.total_requests : 0.0);
    set_response_body(resp, json);
}

static void handle_post_data(http_request_t *req, http_response_t *resp) {
    resp->status_code = 201;
    strcpy(resp->status_text, "Created");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json[512];
    snprintf(json, sizeof(json),
             "{\"status\":\"created\",\"received_bytes\":%zu,\"body\":%s}",
             req->body_length,
             req->body ? req->body : "null");
    set_response_body(resp, json);
}

static void handle_put_data(http_request_t *req, http_response_t *resp) {
    resp->status_code = 200;
    strcpy(resp->status_text, "OK");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json[512];
    snprintf(json, sizeof(json),
             "{\"status\":\"updated\",\"path\":\"%s\",\"received_bytes\":%zu}",
             req->path, req->body_length);
    set_response_body(resp, json);
}

static void handle_delete_data(http_request_t *req, http_response_t *resp) {
    resp->status_code = 200;
    strcpy(resp->status_text, "OK");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json[256];
    snprintf(json, sizeof(json),
             "{\"status\":\"deleted\",\"path\":\"%s\"}", req->path);
    set_response_body(resp, json);
}

static void handle_static_file(http_request_t *req, http_response_t *resp) {
    resp->status_code = 200;
    strcpy(resp->status_text, "OK");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");
    set_response_header(resp, "Cache-Control", "max-age=3600");

    /* Determine content type from extension */
    const char *ext = strrchr(req->path, '.');
    if (ext) {
        if (strcmp(ext, ".css") == 0) {
            set_response_header(resp, "Content-Type", "text/css");
            set_response_body(resp, "body { font-family: Arial, sans-serif; margin: 20px; }");
        } else if (strcmp(ext, ".js") == 0) {
            set_response_header(resp, "Content-Type", "application/javascript");
            set_response_body(resp, "console.log('Embedded server JS loaded');");
        } else if (strcmp(ext, ".ico") == 0) {
            set_response_header(resp, "Content-Type", "image/x-icon");
            set_response_body(resp, "");
        } else {
            set_response_header(resp, "Content-Type", "application/octet-stream");
            set_response_body(resp, "");
        }
    } else {
        set_response_header(resp, "Content-Type", "text/plain");
        set_response_body(resp, "File not found in static resources");
    }
}

static void handle_not_found(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 404;
    strcpy(resp->status_text, "Not Found");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json[256];
    snprintf(json, sizeof(json),
             "{\"error\":\"not_found\",\"path\":\"%s\"}", req->path);
    set_response_body(resp, json);
}

static void handle_method_not_allowed(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 405;
    strcpy(resp->status_text, "Method Not Allowed");
    set_response_header(resp, "Content-Type", "application/json");
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");
    set_response_body(resp, "{\"error\":\"method_not_allowed\"}");
}

static int route_request(http_request_t *req, http_response_t *resp) {
    if (!req || !resp) return -1;

    /* Route based on method and path */
    if (req->method == HTTP_GET) {
        if (strcmp(req->path, "/") == 0) {
            handle_get_root(req, resp);
        } else if (strcmp(req->path, "/api/status") == 0) {
            handle_get_status(req, resp);
        } else if (strcmp(req->path, "/api/stats") == 0) {
            handle_get_stats(req, resp);
        } else if (strncmp(req->path, "/static/", 8) == 0 ||
                   strcmp(req->path, "/favicon.ico") == 0) {
            handle_static_file(req, resp);
        } else {
            handle_not_found(req, resp);
            return -1;
        }
    } else if (req->method == HTTP_POST) {
        if (strncmp(req->path, "/api/data", 9) == 0) {
            handle_post_data(req, resp);
        } else {
            handle_not_found(req, resp);
            return -1;
        }
    } else if (req->method == HTTP_PUT) {
        if (strncmp(req->path, "/api/data", 9) == 0) {
            handle_put_data(req, resp);
        } else {
            handle_not_found(req, resp);
            return -1;
        }
    } else if (req->method == HTTP_DELETE) {
        if (strncmp(req->path, "/api/data", 9) == 0) {
            handle_delete_data(req, resp);
        } else {
            handle_not_found(req, resp);
            return -1;
        }
    } else {
        handle_method_not_allowed(req, resp);
        return -1;
    }

    return 0;
}

static int simulate_receive_request(const char **request_data, size_t *data_len) {
    static int request_index = 0;
    static int cycle_count = 0;
    static const int max_cycles = 3;

    if (simulated_requests[request_index] == NULL) {
        request_index = 0;
        cycle_count++;
        if (cycle_count >= max_cycles) {
            return -1; /* Signal to stop the server */
        }
    }

    *request_data = simulated_requests[request_index];
    *data_len = strlen(simulated_requests[request_index]);
    request_index++;

    return 0;
}

static void simulate_send_response(const http_response_t *resp) {
    /* In a real server, this would write to a socket */
    g_stats.bytes_sent += resp->raw_length;
    (void)resp;
}

static double get_time_ms(void) {
    struct timespec ts;
    clock_gettime(CLOCK_MONOTONIC, &ts);
    return ts.tv_sec * 1000.0 + ts.tv_nsec / 1000000.0;
}

int main(void) {
    printf("========================================\n");
    printf("  Embedded HTTP Server Starting\n");
    printf("========================================\n\n");

    bool running = true;

    while (running) {
        const char *raw_data = NULL;
        size_t data_len = 0;

        /* Simulate receiving a request (in real server: accept/read from socket) */
        if (simulate_receive_request(&raw_data, &data_len) != 0) {
            printf("\n--- Server shutting down gracefully ---\n");
            running = false;
            break;
        }

        double start_time = get_time_ms();

        g_stats.total_requests++;
        g_stats.bytes_received += data_len;

        /* Allocate request and response structures */
        http_request_t *request = allocate_request();
        if (!request) {
            fprintf(stderr, "ERROR: Failed to allocate request #%lu\n",
                    g_stats.total_requests);
            g_stats.failed_requests++;
            continue;
        }

        http_response_t *response = allocate_response();
        if (!response) {
            fprintf(stderr, "ERROR: Failed to allocate response #%lu\n",
                    g_stats.total_requests);
            free_request(request);
            g_stats.failed_requests++;
            continue;
        }

        /* Parse the incoming request */
        if (parse_request(request, raw_data, data_len) != 0) {
            fprintf(stderr, "ERROR: Failed to parse request #%lu\n",
                    g_stats.total_requests);
            response->status_code = 400;
            strcpy(response->status_text, "Bad Request");
            set_response_header(response, "Content-Type", "application/json");
            set_response_body(response, "{\"error\":\"bad_request\"}");
            build_response(response);
            simulate_send_response(response);
            free_request(request);
            free_response(response);
            g_stats.failed_requests++;
            continue;
        }

        /* Log the request */
        printf("[Request #%lu] %s %s %s",
               g_stats.total_requests,
               method_to_string(request->method),
               request->path,
               request->version);

        if (request->header_count > 0) {
            const char *host = get_request_header(request, "Host");
            if (host) {
                printf(" (Host: %s)", host);
            }
        }

        if (request->body_length > 0) {
            printf(" [body: %zu bytes]", request->body_length);
        }

        printf("\n");

        /* Route and handle the request */
        int route_result = route_request(request, response);

        /* Add common headers */
        set_response_header(response, "Connection", "keep-alive");

        /* Build the raw response */
        if (build_response(response) != 0) {
            fprintf(stderr, "ERROR: Failed to build response for request #%lu\n",
                    g_stats.total_requests);
            free_request(request);
            free_response(response);
            g_stats.failed_requests++;
            continue;
        }

        /* Send the response */
        simulate_send_response(response);

        double end_time = get_time_ms();
        double elapsed = end_time - start_time;
        g_stats.total_processing_time_ms += elapsed;

        if (route_result == 0) {
            g_stats.successful_requests++;
        } else {
            g_stats.failed_requests++;
        }

        printf("  -> Response: %d %s (%zu bytes, %.3f ms)\n",
               response->status_code,
               response->status_text,
               response->raw_length,
               elapsed);

        /* Free all allocated memory for this request cycle */
        free_request(request);
        request = NULL;

        free_response(response);
        response = NULL;
    }

    /* Print final statistics */
    printf("\n========================================\n");
    printf("  Server Statistics\n");
    printf("========================================\n");
    printf("  Total requests:      %lu\n", g_stats.total_requests);
    printf("  Successful:          %lu\n", g_stats.successful_requests);
    printf("  Failed:              %lu\n", g_stats.failed_requests);
    printf("  Bytes received:      %lu\n", g_stats.bytes_received);
    printf("  Bytes sent:          %lu\n", g_stats.bytes_sent);
    printf("  Total processing:    %.3f ms\n", g_stats.total_processing_time_ms);
    if (g_stats.total_requests > 0) {
        printf("  Avg per request:     %.3f ms\n",
               g_stats.total_processing_time_ms / g_stats.total_requests);
    }
    printf("========================================\n");
    printf("  Server stopped cleanly.\n");
    printf("========================================\n");

    return 0;
}