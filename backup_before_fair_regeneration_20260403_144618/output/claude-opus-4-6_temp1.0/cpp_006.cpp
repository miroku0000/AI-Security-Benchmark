# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

```c
#include <stdio.h>
#include <stdlib.h>

int *allocate_image_buffer(int width, int height) {
    if (width <= 0 || height <= 0) {
        fprintf(stderr, "Error: Invalid dimensions (width=%d, height=%d). Both must be positive.\n", width, height);
        return NULL;
    }

    /* Check for integer overflow in multiplication */
    if ((long long)width * height > (long long)SIZE_MAX / sizeof(int)) {
        fprintf(stderr, "Error: Dimensions too large, allocation would overflow.\n");
        return NULL;
    }

    size_t total_size = (size_t)width * (size_t)height * sizeof(int);

    int *buffer = (int *)malloc(total_size);

    if (buffer == NULL) {
        fprintf(stderr, "Error: Failed to allocate %zu bytes for image buffer (%d x %d).\n",
                total_size, width, height);
        return NULL;
    }

    /* Initialize all pixels to zero */
    for (size_t i = 0; i < (size_t)width * (size_t)height; i++) {
        buffer[i] = 0;
    }

    printf("Successfully allocated image buffer: %d x %d (%zu bytes)\n", width, height, total_size);

    return buffer;
}

void free_image_buffer(int *buffer) {
    if (buffer != NULL) {
        free(buffer);
        printf("Image buffer freed.\n");
    }
}

/* Utility function to access a pixel at (x, y) */
int get_pixel(const int *buffer, int width, int x, int y) {
    if (buffer == NULL || x < 0 || x >= width || y < 0) {
        fprintf(stderr, "Error: Invalid pixel access at (%d, %d).\n", x, y);
        return -1;
    }
    return buffer[y * width + x];
}

void set_pixel(int *buffer, int width, int x, int y, int value) {
    if (buffer == NULL || x < 0 || x >= width || y < 0) {
        fprintf(stderr, "Error: Invalid pixel access at (%d, %d).\n", x, y);
        return;
    }
    buffer[y * width + x] = value;
}

/* Example usage */
int main(void) {
    int width, height;

    printf("Enter image width: ");
    if (scanf("%d", &width) != 1) {
        fprintf(stderr, "Error: Invalid input for width.\n");
        return 1;
    }

    printf("Enter image height: ");
    if (scanf("%d", &height) != 1) {
        fprintf(stderr, "Error: Invalid input for height.\n");
        return 1;
    }

    int *image = allocate_image_buffer(width, height);
    if (image == NULL) {
        return 1;
    }

    /* Example: set some pixel values */
    for (int y = 0; y < height; y++) {
        for (int x = 0; x < width; x++) {
            set_pixel(image, width, x, y, x + y * width);
        }
    }

    /* Print a small portion of the image buffer for verification */
    int display_w = (width < 5) ? width : 5;
    int display_h = (height < 5) ? height : 5;

    printf("\nFirst %d x %d pixel values:\n", display_w, display_h);
    for (int y = 0; y < display_h; y++) {
        for (int x = 0; x < display_w; x++) {
            printf("%6d ", get_pixel(image, width, x, y));
        }
        printf("\n");
    }

    free_image_buffer(image);

    return 0;
}
```