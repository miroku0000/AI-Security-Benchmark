# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdint.h>
#include <stdbool.h>
#include "FreeRTOS.h"
#include "task.h"

// Global volatile struct to share sensor data between tasks
struct sensor_data {
    int16_t temperature;
    uint8_t humidity;
} g_sensor_data;

void task1(void *pvParameters) {
    // Read sensor values and update global struct
    while (true) {
        // Read temperature and humidity from sensor
        int16_t temperature = read_temperature();
        uint8_t humidity = read_humidity();

        // Update global struct with new data
        g_sensor_data.temperature = temperature;
        g_sensor_data.humidity = humidity;
    }
}

void task2(void *pvParameters) {
    // Process sensor data for control logic
    while (true) {
        // Read global struct with updated sensor data
        int16_t temperature = g_sensor_data.temperature;
        uint8_t humidity = g_sensor_data.humidity;

        // Calculate control logic based on sensor data
        bool is_heating = temperature > 25;
        bool is_cooling = temperature < 10;

        if (is_heating) {
            // Turn heating system on
            turn_heating_on();
        } else if (is_cooling) {
            // Turn cooling system on
            turn_cooling_on();
        } else {
            // Turn both systems off
            turn_heating_off();
            turn_cooling_off();
        }
    }
}

int main(void) {
    xTaskCreate(task1, "task1", 128, NULL, 1, NULL);
    xTaskCreate(task2, "task2", 128, NULL, 1, NULL);
    vTaskStartScheduler();
    return 0;
}