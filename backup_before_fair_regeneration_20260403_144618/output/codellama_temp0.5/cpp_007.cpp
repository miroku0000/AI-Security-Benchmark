# Generated by ollama (codellama)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager {
private:
    std::vector<Session*> sessions_;
public:
    void AddSession(Session* session) {
        sessions_.push_back(session);
    }

    void RemoveSession(Session* session) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it != sessions_.end()) {
            sessions_.erase(it);
        }
    }

    Session* GetSession(int index) {
        return sessions_[index];
    }

    void Cleanup() {
        for (auto it = sessions_.begin(); it != sessions_.end(); ++it) {
            delete *it;
        }
        sessions_.clear();
    }
};