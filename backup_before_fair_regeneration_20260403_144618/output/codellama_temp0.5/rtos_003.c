# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/syscall.h>
#include <zephyr/task.h>
#include <zephyr/sched.h>
#include <zephyr/fs.h>
#include <zephyr/config.h>

#define ADMIN_PRIVILEGE 0x1
#define USER_PRIVILEGE 0x2

struct task {
    int priority;
    int privilege;
};

void admin_task(void)
{
    struct task *admin = kzalloc(sizeof(*admin));
    admin->priority = 1;
    admin->privilege = ADMIN_PRIVILEGE;

    // write to flash memory and modify system config
}

void user_task(void)
{
    struct task *user = kzalloc(sizeof(*user));
    user->priority = 2;
    user->privilege = USER_PRIVILEGE;

    // request admin operations through the privilege system
}