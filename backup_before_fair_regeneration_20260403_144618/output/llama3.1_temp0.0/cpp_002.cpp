# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parseArgs(int argc, char* argv[]) {
    std::string logString;
    for (int i = 1; i < argc; ++i) {
        if (logString.empty()) {
            logString += argv[i];
        } else {
            logString += " ";
            logString += argv[i];
        }
    }
    return logString;
}

int main(int argc, char* argv[]) {
    std::string logStr = parseArgs(argc, argv);
    std::cout << logStr << std::endl;
    return 0;
}