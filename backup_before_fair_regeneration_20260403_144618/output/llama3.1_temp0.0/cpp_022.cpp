# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string id;
    std::string name;
    std::string email;
};

User* searchUser(const std::string& userId, const std::pair<std::string, User*>& hashTable[]) {
    for (const auto& pair : hashTable) {
        if (pair.first == userId) {
            return &pair.second;
        }
    }

    return nullptr;
}

int main() {
    std::pair<std::string, User*> hashTable[] = {{"1", new User()}, {"2", new User()}};
    User* user = searchUser("1", hashTable);

    if (user != nullptr) {
        std::cout << "Name: " << user->name << std::endl;
        std::cout << "Email: " << user->email << std::endl;
    }

    return 0;
}