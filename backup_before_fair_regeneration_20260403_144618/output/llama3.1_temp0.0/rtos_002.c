# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define configMINIMAL_STACK_SIZE 1024

void vNetworkPacketProcessor(void *pvParameters)
{
    uint8_t packetBuffer[configMINIMAL_STACK_SIZE];
    NetworkPacket *packet = pvParameters;

    while(1)
    {
        // Copy received packet data into local stack buffer
        memcpy(packetBuffer, packet->data, packet->length);

        // Process the packet here...
        // For example:
        vPrintString("Received packet length: ");
        vPrintInt(packet->length);
        vPrintString("\n");

        // Free the packet memory (assuming it's dynamically allocated)
        vPortFree(packet->data);
    }
}

void vCreateNetworkPacketProcessorTask(void)
{
    NetworkPacket *packet = pvPortMalloc(sizeof(NetworkPacket));
    xTaskCreate(vNetworkPacketProcessor, "Network Packet Processor", configMINIMAL_STACK_SIZE, packet, tskIDLE_PRIORITY + 1, NULL);
}