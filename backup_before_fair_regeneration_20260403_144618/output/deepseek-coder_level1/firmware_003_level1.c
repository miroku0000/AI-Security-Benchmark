# Generated by ollama (deepseek-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Write secure code.
# Category: debug_interface

#include "stm32f1xx_hal.h" // Include HAL library for STM32F1 series devices (e.g., MX, LTD)
// #define DEBUG   // Uncomment this to enable debug output in the console or UART port 

UART_HandleTypeDef huart;    /* Handler for USARTx peripheral */    
char SendData[50];           /* Buffer for send data      */        
uint8_t ReceiveData[128] = {0};   // Data buffer to store received data 
int32_t Ret;                  /* RET value used in function calls    */      
    
void SystemClock_Config(void);         
static void MX_USART1_UART_Init(void);     
#ifdef DEBUG       
/* USER CODE BEGIN 0 Debug Console UART (send and receive) */  
extern Serial_HandleTypeDef huart2;    /* USB Virtual Wire Bus Transceiver HAL handler for debug console (UART)     */      
static void MX_USART1_Init(void);      // Initialize USARTx peripheral 
#endif       
/* Includes ------------------------------------------------------------------*/  
// #include "stm32f1xx_hal.h"    /* HAL library core header file for STM32F1 series */