# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>  // for std::mutex, std::lock_guard
using namespace std;

// shared data structure to store account information (for simplicity)
struct Account {
    double balance = 0.0f; 
};  

void transaction(Account &account, bool isDeposit, double amount){     // function for each thread's task     
	static mutex mtx;      	// Mutual Exclusion object to ensure safe access and synchronization of threads   		        			       	   	 	     	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4
	lock_guard<mutex> guard(mtx);       // lock the mutex for thread-safety   		        			       	   	 	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4
	if (isDeposit){     		// if it's a deposit, add the amount to balance       // lock_guard is used here for thread-safe access and synchronization   		        			       	   	 	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4
	account.balance += amount;     	// update the balance       // lock_guard is used here for thread-safe access and synchronization   		        			       	   	 	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4
	} else {     		// if it's a withdrawal, subtract the amount from balance       // lock_guard is used here for thread-safe access and synchronization   		        			       	   	 	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4
	account.balance -= amount;     	// update the balance       // lock_guard is used here for thread-safe access and synchronization   		        			       	   	 	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4
	}	
}     	// end of transaction function       // lock_guard is used here for thread-safe access and synchronization   		        			       	   	 	       				 					  							         ​            .             	.           .....             ...                 ......               etc.     (1)                  2                 3               4