# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <sys/types.h>
#include <sys/socket.h>
#include <fcntl.h>
#include <unistd.h>
#include <vector>
#include <memory>

class FileHandlePool {
private:
    std::vector<std::unique_ptr<int, decltype(&close)> > fileHandles;

public:
    void add(int fd) {
        fileHandles.emplace_back(new int(fd), &close);
    }

    bool remove(int fd) {
        for (auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
            if ((*it)->get() == fd) {
                it = fileHandles.erase(it);
                return true;
            }
        }
        return false;
    }

    void cleanup() {
        for (auto &handle : fileHandles) {
            close(handle.get());
        }
        fileHandles.clear();
    }
};