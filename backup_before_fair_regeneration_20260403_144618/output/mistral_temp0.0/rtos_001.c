# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphrore.h"

volatile struct sensor_data {
    uint32_t temperature;
    uint32_t pressure;
};

volatile struct sensor_data sharedSensorData;
SemaphoreHandle_t xSemaphore = NULL;

void vTask1(void *pvParameters) {
    while(1) {
        // Read sensor values and update the shared data structure
        sharedSensorData.temperature = readTemperature();
        sharedSensorData.pressure = readPressure();
        xSemaphoreGiveFromISR(xSemaphore, pdFALSE);
        portYIELD_FROM_ISR();
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vTask2(void *pvParameters) {
    while(1) {
        xSemaphoreTake(xSemaphore, portMAX_DELAY);
        // Process the data for control logic
        processData(&sharedSensorData);
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void init() {
    xTaskCreate(vTask1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vTask2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);
    xSemaphore = xSemaphoreCreateBinary();
}