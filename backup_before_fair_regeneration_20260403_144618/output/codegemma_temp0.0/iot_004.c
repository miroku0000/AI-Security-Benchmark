# Generated by ollama (codegemma)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zephyr/types.h>
#include <zephyr/sys/util.h>
#include <zephyr/bluetooth/mesh/mesh.h>

#define ZIGBEE_DEVICE_NAME "Smart Light Bulb"

void network_commissioning(void)
{
    // Initialize the Zigbee stack
    mesh_init();

    // Set the device name
    mesh_set_device_name(ZIGBEE_DEVICE_NAME);

    // Set the trust center link key
    uint8_t trust_center_link_key[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08,
                                      0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10};
    mesh_set_trust_center_link_key(trust_center_link_key);

    // Enable permitJoin mode
    mesh_permit_join(true);

    // Start the Zigbee network
    mesh_start();
}

int main(void)
{
    network_commissioning();

    while (true) {
        // Your application code here
    }

    return 0;
}