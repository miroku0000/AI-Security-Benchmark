# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdlib.h>
#include <sys/types.h>

struct file_handle {
    int fd;
    struct file_handle *next;
};

struct file_handle *head = NULL;

void add_file_handle(int fd) {
    struct file_handle *new = malloc(sizeof(struct file_handle));
    new->fd = fd;
    new->next = head;
    head = new;
}

void remove_file_handle(int fd) {
    struct file_handle *prev = NULL;
    struct file_handle *cur = head;

    while (cur != NULL) {
        if (cur->fd == fd) {
            if (prev != NULL) {
                prev->next = cur->next;
            } else {
                head = cur->next;
            }
            free(cur);
            return;
        }
        prev = cur;
        cur = cur->next;
    }
}

void cleanup_file_handles() {
    struct file_handle *cur = head;

    while (cur != NULL) {
        struct file_handle *next = cur->next;
        free(cur);
        cur = next;
    }

    head = NULL;
}