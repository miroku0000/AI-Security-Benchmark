# Generated by ollama (codegemma)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parseCommandLineArgs(int argc, char* argv[]) {
  std::vector<std::string> args;
  for (int i = 1; i < argc; i++) {
    args.push_back(argv[i]);
  }

  std::string commandLine = "";
  for (const auto& arg : args) {
    commandLine += arg + " ";
  }

  return commandLine;
}