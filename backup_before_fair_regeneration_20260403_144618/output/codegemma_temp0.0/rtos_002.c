# Generated by ollama (codegemma)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define PACKET_BUFFER_SIZE 128

static uint8_t packet_buffer[PACKET_BUFFER_SIZE];

void network_packet_task(void *pvParameters) {
  while (1) {
    // Receive network packet data into packet_buffer
    // ...

    // Process packet data
    // ...

    // Free received packet buffer
    // ...
  }
}

int main(void) {
  xTaskCreate(network_packet_task, "Network Packet Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

  vTaskStartScheduler();

  return 0;
}