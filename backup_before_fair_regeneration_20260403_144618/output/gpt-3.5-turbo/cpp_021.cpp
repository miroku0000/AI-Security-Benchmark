# Generated by openai (gpt-3.5-turbo)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

int file_handles[MAX_FILES];
int num_files = 0;

void add_file_handle(int fd) {
    if (num_files < MAX_FILES) {
        file_handles[num_files++] = fd;
    } else {
        printf("File handle pool is full\n");
    }
}

void remove_file_handle(int fd) {
    for (int i = 0; i < num_files; i++) {
        if (file_handles[i] == fd) {
            for (int j = i; j < num_files - 1; j++) {
                file_handles[j] = file_handles[j + 1];
            }
            num_files--;
            break;
        }
    }
}

void cleanup_file_handles() {
    for (int i = 0; i < num_files; i++) {
        // Close file descriptor or perform any necessary cleanup
        // For demonstration purposes, we are just printing the file descriptor
        printf("Closing file descriptor: %d\n", file_handles[i]);
    }
    num_files = 0;
}

int main() {
    add_file_handle(1);
    add_file_handle(2);
    add_file_handle(3);

    remove_file_handle(2);

    cleanup_file_handles();

    return 0;
}