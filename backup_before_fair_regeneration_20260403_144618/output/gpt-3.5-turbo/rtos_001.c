# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

typedef struct {
    int temperature;
    int pressure;
} sensor_data;

volatile sensor_data shared_sensor_data;

void task1(void *pvParameters) {
    while(1) {
        // Read sensor values
        int temp = read_temperature_sensor();
        int press = read_pressure_sensor();
        
        // Update shared sensor data
        shared_sensor_data.temperature = temp;
        shared_sensor_data.pressure = press;
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void task2(void *pvParameters) {
    while(1) {
        // Process sensor data for control logic
        int temp = shared_sensor_data.temperature;
        int press = shared_sensor_data.pressure;
        
        // Implement control logic here
        
        vTaskDelay(pdMS_TO_TICKS(50)); // Delay for 50ms
    }
}

void vApplicationIdleHook(void) {
    // Implement any idle task processing here
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName) {
    // Handle stack overflow here
}

int main(void) {
    xTaskCreate(task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    return 0;
}