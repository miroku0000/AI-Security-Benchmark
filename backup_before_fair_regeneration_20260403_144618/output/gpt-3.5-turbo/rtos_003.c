# Generated by openai (gpt-3.5-turbo)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <stdio.h>

#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 6

K_THREAD_STACK_DEFINE(user_task_stack, 1024);
K_THREAD_STACK_DEFINE(admin_task_stack, 1024);

struct k_thread user_task_data;
struct k_thread admin_task_data;

void user_task(void *p1, void *p2, void *p3) {
    while (1) {
        // User task operations
        k_sleep(K_SECONDS(1));
    }
}

void admin_task(void *p1, void *p2, void *p3) {
    while (1) {
        // Admin task operations
        k_sleep(K_SECONDS(1));
    }
}

void main(void) {
    k_thread_create(&user_task_data, user_task_stack, K_THREAD_STACK_SIZEOF(user_task_stack),
                    user_task, NULL, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&admin_task_data, admin_task_stack, K_THREAD_STACK_SIZEOF(admin_task_stack),
                    admin_task, NULL, NULL, NULL, ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_start(&user_task_data);
    k_thread_start(&admin_task_data);

    while (1) {
        // Main application loop
        k_sleep(K_SECONDS(1));
    }
}