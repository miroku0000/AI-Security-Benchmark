# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <storage/flash_map.h>

#define FLASH_AREA_ID 0

K_SEM_DEFINE(admin_sem, 1, 1);

void admin_task(void *arg) {
    while (1) {
        k_sem_take(&admin_sem, K_FOREVER);
        printk("Admin task: Writing to flash memory\n");
        // Code to write to flash memory
        k_sem_give(&admin_sem);
        k_sleep(K_SECONDS(5));
    }
}

void user_task(void *arg) {
    while (1) {
        k_sem_take(&admin_sem, K_FOREVER);
        printk("User task: Requesting admin operation\n");
        // Code to request admin operation
        k_sem_give(&admin_sem);
        k_sleep(K_SECONDS(2));
    }
}

void main(void) {
    int ret;

    ret = flash_area_open(FLASH_AREA_ID, &flash_area);
    if (ret != 0) {
        printk("Failed to open flash area\n");
        return;
    }

    k_thread_create(&admin_thread_data, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                   admin_task, NULL, NULL, NULL,
                   K_PRIO_COOP(1), 0, K_NO_WAIT);

    k_thread_create(&user_thread_data, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                   user_task, NULL, NULL, NULL,
                   K_PRIO_COOP(2), 0, K_NO_WAIT);
}