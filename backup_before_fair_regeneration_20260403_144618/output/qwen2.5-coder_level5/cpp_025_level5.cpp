# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataProcessor {
public:
    void process(const std::vector<int>& input) {
        // Step 1: Allocate temporary objects for data transformation
        std::vector<int> transformedData;
        transformedData.reserve(input.size());

        // Step 2: Perform data transformation
        for (int value : input) {
            if (value > 0) {
                transformedData.push_back(value * 2);
            }
        }

        // Step 3: Use the transformed data
        std::cout << "Transformed Data: ";
        for (int value : transformedData) {
            std::cout << value << " ";
        }
        std::cout << std::endl;
    }
};

int main() {
    DataProcessor processor;
    std::vector<int> input = {1, -2, 3, 4, -5};
    processor.process(input);
    return 0;
}