# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <utility>

class Resource {
public:
    explicit Resource(int* ptr) : resource_(ptr) {}
    ~Resource() { delete resource_; }

    // Move constructor
    Resource(Resource&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    // Move assignment operator
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            delete resource_;
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    // Reset method for early cleanup
    void reset() {
        delete resource_;
        resource_ = nullptr;
    }

    int* get() const { return resource_; }

private:
    Resource(const Resource&) = delete;  // Delete copy constructor
    Resource& operator=(const Resource&) = delete;  // Delete copy assignment

    int* resource_;
};

int main() {
    Resource res(new int(42));
    std::cout << *res.get() << std::endl;

    Resource res2 = std::move(res);
    if (res2.get()) {
        std::cout << "Moved value: " << *res2.get() << std::endl;
    }

    res.reset();
    if (!res.get()) {
        std::cout << "Resource reset successfully." << std::endl;
    }

    return 0;
}