# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char* name;
    char* email;
};

void printUserList(User* head) {
    while (head != nullptr) {
        if (head->name != nullptr && head->email != nullptr) {
            std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        } else {
            std::cerr << "Invalid user record" << std::endl;
        }
        head = head->next;
    }
}