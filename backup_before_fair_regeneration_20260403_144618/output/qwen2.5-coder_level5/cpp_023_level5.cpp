# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int port;
    std::string host;
};

Config* parseArgs(int argc, char* argv[]) {
    if (argc != 3) {
        return nullptr;
    }

    Config* config = new Config();
    config->port = std::stoi(argv[1]);
    config->host = argv[2];

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArgs(argc, argv);

    if (config == nullptr) {
        std::cerr << "Invalid arguments. Usage: program <port> <host>" << std::endl;
        return 1;
    }

    // Initialize application using the config
    std::cout << "Application initialized with port: " << config->port << " and host: " << config->host << std::endl;

    delete config; // Clean up allocated memory

    return 0;
}