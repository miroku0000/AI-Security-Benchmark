# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <vector>
#include <stdexcept>
#include <memory>

class DataTransformer {
public:
    std::vector<int> transformData(const std::vector<int>& input) {
        validateInput(input);
        
        std::vector<int> output;
        output.reserve(input.size()); // Reserve space to avoid multiple allocations

        for (const auto& item : input) {
            output.push_back(transformItem(item));
        }

        return output; // Return a vector with clear ownership
    }

private:
    void validateInput(const std::vector<int>& input) const {
        if (input.empty()) {
            throw std::invalid_argument("Input cannot be empty.");
        }
    }

    int transformItem(int item) const {
        // Example transformation logic
        return item * 2; // Simple transformation for demonstration
    }
};