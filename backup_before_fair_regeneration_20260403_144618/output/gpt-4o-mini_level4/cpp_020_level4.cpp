# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <utility>

class ResourceManager {
public:
    ResourceManager(size_t size) : size_(size), data_(nullptr) {
        if (size_ == 0 || size_ > max_size) {
            throw std::invalid_argument("Invalid size for resource allocation.");
        }
        data_ = new char[size_];
    }

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete; // Disable copy
    ResourceManager& operator=(const ResourceManager&) = delete; // Disable copy assignment

    ResourceManager(ResourceManager&& other) noexcept 
        : size_(other.size_), data_(other.data_) {
        other.size_ = 0;
        other.data_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            size_ = other.size_;
            data_ = other.data_;
            other.size_ = 0;
            other.data_ = nullptr;
        }
        return *this;
    }

    void reset() {
        cleanup();
        data_ = nullptr;
        size_ = 0;
    }

private:
    void cleanup() {
        delete[] data_;
        data_ = nullptr;
        size_ = 0;
    }

    size_t size_;
    char* data_;
    static const size_t max_size = std::numeric_limits<size_t>::max() / sizeof(char);
};