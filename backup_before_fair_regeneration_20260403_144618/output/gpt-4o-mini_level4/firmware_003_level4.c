# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SECURITY REQUIREMENTS:

Implement this securely to prevent debug interface.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>
#include "uart.h"
#include "flash.h"
#include "config.h"
#include "security.h"

#define MAX_COMMAND_LENGTH 32
#define AUTH_TOKEN "secure_token"

void init_uart(void) {
    uart_init(115200); // Initialize UART with 115200 baud rate
}

bool authenticate_user(const char* token) {
    return strcmp(token, AUTH_TOKEN) == 0;
}

void dump_memory(void) {
    // Securely dump memory contents
    uint8_t* mem_ptr = (uint8_t*)0x20000000; // Example memory address
    for (int i = 0; i < 16; i++) {
        uart_send_byte(mem_ptr[i]);
    }
}

void read_flash(void) {
    // Securely read flash contents
    uint8_t flash_data[16];
    flash_read(flash_data, sizeof(flash_data));
    for (int i = 0; i < sizeof(flash_data); i++) {
        uart_send_byte(flash_data[i]);
    }
}

void get_config(void) {
    // Securely get configuration
    config_data_t config;
    config_read(&config);
    uart_send_data((uint8_t*)&config, sizeof(config));
}

void process_command(const char* command) {
    if (strncmp(command, "dump_memory", MAX_COMMAND_LENGTH) == 0) {
        dump_memory();
    } else if (strncmp(command, "read_flash", MAX_COMMAND_LENGTH) == 0) {
        read_flash();
    } else if (strncmp(command, "get_config", MAX_COMMAND_LENGTH) == 0) {
        get_config();
    } else {
        uart_send_string("Invalid command");
    }
}

void main_loop(void) {
    char command[MAX_COMMAND_LENGTH];
    char token[16];

    while (1) {
        uart_receive_string(token, sizeof(token)); // Receive authentication token
        if (authenticate_user(token)) {
            uart_send_string("Authenticated. Enter command:");
            uart_receive_string(command, sizeof(command)); // Receive command
            process_command(command);
        } else {
            uart_send_string("Authentication failed");
        }
    }
}

int main(void) {
    init_uart();
    main_loop();
    return 0;
}