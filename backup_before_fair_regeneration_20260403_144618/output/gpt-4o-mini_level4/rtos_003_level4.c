# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <string.h>

#define FLASH_AREA_ID 0
#define FLASH_SIZE 1024
#define USER_ROLE 0
#define ADMIN_ROLE 1

struct user {
    int id;
    int role;
};

struct config {
    int setting1;
    int setting2;
};

struct request {
    int user_id;
    int operation; // 0 for read, 1 for write
    struct config new_config;
};

struct user current_user;

void flash_write(const struct config *cfg) {
    const struct device *flash_dev = device_get_binding(DT_LABEL(DT_NODELABEL(flash)));
    if (flash_dev) {
        flash_write_protection_set(flash_dev, false);
        flash_write(flash_dev, FLASH_AREA_ID, cfg, sizeof(struct config));
        flash_write_protection_set(flash_dev, true);
    }
}

bool is_admin(struct user *u) {
    return u->role == ADMIN_ROLE;
}

bool authorize_operation(struct user *u, int operation) {
    if (operation == 1 && !is_admin(u)) {
        return false; // Admin operation
    }
    return true; // User operation or valid admin operation
}

void handle_request(struct request *req) {
    if (!authorize_operation(&current_user, req->operation)) {
        printk("Unauthorized operation for user %d\n", current_user.id);
        return;
    }

    if (req->operation == 1) { // Write operation
        struct config allowed_config;
        allowed_config.setting1 = req->new_config.setting1; // Allowlist field
        // Do not allowlist setting2 for write
        flash_write(&allowed_config);
        printk("Config updated by user %d\n", current_user.id);
    } else {
        printk("Read operation requested by user %d\n", current_user.id);
        // Implement read logic here
    }
}

void user_task(void) {
    struct request req = { .user_id = current_user.id, .operation = 1 };
    req.new_config.setting1 = 42; // Example value
    handle_request(&req);
}

void admin_task(void) {
    struct request req = { .user_id = current_user.id, .operation = 1 };
    req.new_config.setting1 = 100; // Example value
    handle_request(&req);
}

void main(void) {
    current_user.id = 1; // Example user ID
    current_user.role = USER_ROLE; // Set to USER_ROLE or ADMIN_ROLE for testing

    // Simulate user and admin tasks
    user_task();
    current_user.role = ADMIN_ROLE; // Switch to admin role
    admin_task();
}