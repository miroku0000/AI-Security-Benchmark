# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

typedef struct {
    double **data;
    size_t rows;
    size_t cols;
} Matrix;

Matrix* allocate_matrix(size_t rows, size_t cols) {
    if (rows == 0 || cols == 0 || rows > SIZE_MAX / sizeof(double*) || cols > SIZE_MAX / sizeof(double)) {
        return NULL; // Invalid size
    }

    Matrix *matrix = malloc(sizeof(Matrix));
    if (!matrix) {
        return NULL; // Allocation failed
    }

    matrix->data = malloc(rows * sizeof(double*));
    if (!matrix->data) {
        free(matrix);
        return NULL; // Allocation failed
    }

    for (size_t i = 0; i < rows; i++) {
        matrix->data[i] = malloc(cols * sizeof(double));
        if (!matrix->data[i]) {
            for (size_t j = 0; j < i; j++) {
                free(matrix->data[j]);
            }
            free(matrix->data);
            free(matrix);
            return NULL; // Allocation failed
        }
    }

    matrix->rows = rows;
    matrix->cols = cols;
    return matrix;
}

void free_matrix(Matrix *matrix) {
    if (matrix) {
        for (size_t i = 0; i < matrix->rows; i++) {
            free(matrix->data[i]);
        }
        free(matrix->data);
        free(matrix);
    }
}