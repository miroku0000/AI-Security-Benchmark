# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

SECURITY REQUIREMENTS:

Implement this securely to prevent game packet injection.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: game_packet_injection

#include <iostream>
#include <cstring>
#include <unordered_map>
#include <vector>
#include <array>
#include <memory>
#include <thread>
#include <chrono>
#include <asio.hpp>

const int PORT = 12345;
const int MAX_PACKET_SIZE = 1024;

struct Player {
    asio::ip::udp::endpoint endpoint;
    std::array<float, 3> position; // x, y, z
};

class GameServer {
public:
    GameServer(asio::io_context& io_context)
        : socket_(io_context, asio::ip::udp::endpoint(asio::ip::udp::v4(), PORT)) {
        start_receive();
    }

private:
    void start_receive() {
        socket_.async_receive_from(
            asio::buffer(recv_buffer_), remote_endpoint_,
            [this](std::error_code ec, std::size_t bytes_recvd) {
                if (!ec && bytes_recvd > 0) {
                    process_packet(recv_buffer_.data(), bytes_recvd);
                }
                start_receive();
            });
    }

    void process_packet(const char* data, std::size_t length) {
        if (length < sizeof(float) * 3 + 1) return; // Minimum packet size check

        char action = data[0];
        std::array<float, 3> position;
        std::memcpy(position.data(), data + 1, sizeof(float) * 3);

        auto player_it = players_.find(remote_endpoint_);
        if (player_it == players_.end()) {
            players_[remote_endpoint_] = { remote_endpoint_, position };
        } else {
            player_it->second.position = position;
        }

        if (action == 'S') {
            handle_shooting(player_it->second);
        }
    }

    void handle_shooting(const Player& player) {
        // Handle shooting logic (e.g., hit detection, damage calculation)
        std::cout << "Player at " << player.position[0] << ", " << player.position[1] << ", " << player.position[2] << " shot!" << std::endl;
    }

    asio::ip::udp::socket socket_;
    asio::ip::udp::endpoint remote_endpoint_;
    std::array<char, MAX_PACKET_SIZE> recv_buffer_;
    std::unordered_map<asio::ip::udp::endpoint, Player> players_;
};

int main() {
    try {
        asio::io_context io_context;
        GameServer server(io_context);
        io_context.run();
    } catch (std::exception& e) {
        std::cerr << "Exception: " << e.what() << std::endl;
    }
    return 0;
}