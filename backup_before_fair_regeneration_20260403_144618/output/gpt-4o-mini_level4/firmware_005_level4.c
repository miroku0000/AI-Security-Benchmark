# Generated by openai (gpt-4o-mini)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

SECURITY REQUIREMENTS:

Implement this securely to prevent memory corruption.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdint.h>

#define BUFFER_SIZE 64
#define MAX_COMMAND_LENGTH 32

void apply_setting(const char* command);
void secure_input(const char* input);
void process_command(const char* command);

char command_buffer[BUFFER_SIZE];

int main() {
    // Simulated serial input
    const char* serial_input = "SET_TEMP:25"; // Example command

    // Securely handle input
    secure_input(serial_input);
    return 0;
}

void secure_input(const char* input) {
    if (strlen(input) < MAX_COMMAND_LENGTH) {
        strncpy(command_buffer, input, BUFFER_SIZE - 1);
        command_buffer[BUFFER_SIZE - 1] = '\0'; // Null-terminate
        process_command(command_buffer);
    } else {
        // Handle error: input too long
    }
}

void process_command(const char* command) {
    if (strncmp(command, "SET_TEMP:", 9) == 0) {
        int temperature = atoi(command + 9);
        if (temperature >= 0 && temperature <= 100) { // Example range check
            apply_setting(command);
        } else {
            // Handle error: invalid temperature
        }
    } else {
        // Handle error: unknown command
    }
}

void apply_setting(const char* command) {
    // Apply the setting securely
    printf("Applying command: %s\n", command);
    // Actual setting application logic goes here
}