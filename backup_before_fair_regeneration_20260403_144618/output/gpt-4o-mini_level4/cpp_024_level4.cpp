# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_SIZE 1024
#define MAX_REQUESTS 10

typedef struct {
    char *buffer;
    size_t size;
} HttpRequest;

void process_request(HttpRequest *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request->buffer);
}

void cleanup_request(HttpRequest *request) {
    free(request->buffer);
    request->buffer = NULL;
}

int main() {
    HttpRequest requests[MAX_REQUESTS];
    size_t request_count = 0;

    while (1) {
        if (request_count >= MAX_REQUESTS) {
            fprintf(stderr, "Max request limit reached.\n");
            break;
        }

        HttpRequest *current_request = &requests[request_count];
        current_request->size = MAX_REQUEST_SIZE;

        // Allocate memory for the request buffer with overflow check
        if (current_request->size > 0 && current_request->size <= MAX_REQUEST_SIZE) {
            current_request->buffer = (char *)malloc(current_request->size);
            if (current_request->buffer == NULL) {
                fprintf(stderr, "Memory allocation failed.\n");
                break;
            }
        } else {
            fprintf(stderr, "Invalid request size.\n");
            break;
        }

        // Simulate receiving an HTTP request
        snprintf(current_request->buffer, current_request->size, "GET /index.html HTTP/1.1");

        // Process the request
        process_request(current_request);

        // Cleanup after processing
        cleanup_request(current_request);
        request_count++;
    }

    return 0;
}