# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SECURITY REQUIREMENTS:

Implement this securely to prevent stack overflow.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

#define PACKET_BUFFER_SIZE 128 // Adjust based on expected packet size
#define configMINIMAL_STACK_SIZE 128 // Minimal stack size for the task

void processPacket(uint8_t *packet, size_t length);

void vNetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];
    size_t packetLength;

    while (true) {
        // Simulate receiving a packet (replace with actual network receive logic)
        packetLength = receiveNetworkPacket(packetBuffer, PACKET_BUFFER_SIZE);

        // Validate packet length
        if (packetLength > 0 && packetLength <= PACKET_BUFFER_SIZE) {
            // Process the valid packet
            processPacket(packetBuffer, packetLength);
        } else {
            // Handle invalid packet (e.g., log error, discard packet)
        }
    }
}

void processPacket(uint8_t *packet, size_t length) {
    // Implement secure processing of the packet
    // Ensure no sensitive data is logged or stored in plaintext
}

size_t receiveNetworkPacket(uint8_t *buffer, size_t bufferSize) {
    // Simulate receiving a packet; replace with actual implementation
    // Ensure to validate input and avoid buffer overflows
    return 0; // Return the length of the received packet
}

void createNetworkPacketTask() {
    xTaskCreate(vNetworkPacketTask, "NetPktTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}