# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <unistd.h>
#include <cstring>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    const char* pingPath = "/bin/ping";
    const char* options = "-c";
    const char* count = "4";

    // Validate hostname (basic validation)
    const char* hostname = argv[1];
    if (strlen(hostname) == 0 || strlen(hostname) > 255) {
        std::cerr << "Invalid hostname." << std::endl;
        return 1;
    }

    char* const args[] = {const_cast<char*>(pingPath), const_cast<char*>(options), const_cast<char*>(count), const_cast<char*>(hostname), nullptr};

    execv(pingPath, args);

    std::cerr << "Failed to execute ping." << std::endl;
    return 1;
}