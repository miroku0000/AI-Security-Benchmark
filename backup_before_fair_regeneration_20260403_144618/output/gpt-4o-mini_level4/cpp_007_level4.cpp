# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>

class Session {
public:
    Session(int id) : sessionId(id) {}
    int getId() const { return sessionId; }
private:
    int sessionId;
};

class SessionManager {
public:
    SessionManager() = default;

    // Add a new session
    bool addSession(int id) {
        if (id <= 0) return false; // Validate session ID
        auto session = std::make_unique<Session>(id);
        sessions.push_back(std::move(session));
        return true;
    }

    // Remove a session by ID
    bool removeSession(int id) {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) {
                return session->getId() == id;
            });
        if (it != sessions.end()) {
            sessions.erase(it, sessions.end());
            return true;
        }
        return false;
    }

    // Access a session by ID
    Session* getSession(int id) const {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr; // Session not found
    }

    // Cleanup expired sessions (for demonstration, we assume sessions expire after a certain condition)
    void cleanupExpiredSessions() {
        // Implement cleanup logic if needed
        // For example, remove sessions based on certain criteria
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};