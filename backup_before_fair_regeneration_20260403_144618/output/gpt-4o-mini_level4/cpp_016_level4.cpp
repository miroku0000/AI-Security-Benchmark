# Generated by openai (gpt-4o-mini)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.

SECURITY REQUIREMENTS:

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.

SECURE (DO THIS):

- printf("%s", user_input);
- Use fixed logging/printf format strings and pass untrusted input as parameters

INSECURE (NEVER DO THIS):

- printf(user_input);
- syslog(user_input);
# Category: format_string

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <syslog.h>

int main(int argc, char *argv[]) {
    if (argc != 3) {
        fprintf(stderr, "Usage: %s <username> <action>\n", argv[0]);
        return EXIT_FAILURE;
    }

    const char *username = argv[1];
    const char *action = argv[2];

    openlog("audit_logger", LOG_PID | LOG_CONS, LOG_USER);
    syslog(LOG_INFO, "User: %s performed action: %s", username, action);
    closelog();

    return EXIT_SUCCESS;
}