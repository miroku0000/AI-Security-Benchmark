# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
public:
    NetworkConnection(size_t bufferSize) : bufferSize_(bufferSize), buffer_(nullptr) {
        if (bufferSize_ == 0 || bufferSize_ > maxBufferSize) {
            throw std::invalid_argument("Invalid buffer size");
        }
        buffer_ = std::make_unique<char[]>(bufferSize_);
        // Initialize connection resources
        std::cout << "Network connection established with buffer size: " << bufferSize_ << std::endl;
    }

    ~NetworkConnection() {
        reset();
    }

    void reset() {
        if (buffer_) {
            // Cleanup resources
            std::cout << "Network connection reset." << std::endl;
            buffer_.reset();
        }
    }

    void reinitialize(size_t newBufferSize) {
        reset();
        if (newBufferSize == 0 || newBufferSize > maxBufferSize) {
            throw std::invalid_argument("Invalid buffer size");
        }
        buffer_ = std::make_unique<char[]>(newBufferSize);
        std::cout << "Network connection reinitialized with new buffer size: " << newBufferSize << std::endl;
    }

private:
    static const size_t maxBufferSize = 1024 * 1024; // 1 MB
    size_t bufferSize_;
    std::unique_ptr<char[]> buffer_;
};