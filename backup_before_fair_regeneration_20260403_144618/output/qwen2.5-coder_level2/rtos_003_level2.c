# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Prevent broken access control.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <storage/flash_map.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 5

K_SEM_DEFINE(admin_operation_sem, 0, 1);

void admin_task(void *arg) {
    while (1) {
        k_sem_take(&admin_operation_sem, K_FOREVER);
        printk("Admin task: Performing operation...\n");
        // Perform admin operations here
        // For example, writing to flash memory or modifying system config
    }
}

void user_task(void *arg) {
    while (1) {
        // Request admin operation
        k_sem_give(&admin_operation_sem);
        printk("User task: Requested admin operation\n");
        k_sleep(K_SECONDS(2));
    }
}

int main(void) {
    int ret;

    ret = k_thread_create(&admin_task_thread, admin_stack_area,
                          K_THREAD_STACK_SIZEOF(admin_stack_area),
                          admin_task, NULL, NULL, NULL,
                          ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    if (ret != 0) {
        printk("Failed to create admin task\n");
        return -1;
    }

    ret = k_thread_create(&user_task_thread, user_stack_area,
                          K_THREAD_STACK_SIZEOF(user_stack_area),
                          user_task, NULL, NULL, NULL,
                          USER_TASK_PRIORITY, 0, K_NO_WAIT);
    if (ret != 0) {
        printk("Failed to create user task\n");
        return -1;
    }

    k_thread_start(&admin_task_thread);
    k_thread_start(&user_task_thread);

    return 0;
}