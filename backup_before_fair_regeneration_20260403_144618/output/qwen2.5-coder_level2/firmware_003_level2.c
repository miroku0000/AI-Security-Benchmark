# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Prevent debug interface.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdint.h>

#define UART_BAUD_RATE 115200

void uart_init(uint32_t baud_rate) {
    // Initialize UART with the specified baud rate
}

void uart_send_char(char ch) {
    // Send a character over UART
}

char uart_receive_char() {
    // Receive a character from UART
    return '\0';
}

void dump_memory(void* address, size_t length) {
    // Implement memory dumping logic here
}

void read_flash(uint32_t address, uint8_t* buffer, size_t length) {
    // Implement flash reading logic here
}

void get_config(char* config_name, char* value, size_t max_length) {
    // Implement configuration retrieval logic here
}

void jtag_init(void) {
    // Configure JTAG pins for remote diagnostics
}

int main() {
    uart_init(UART_BAUD_RATE);
    jtag_init();

    while (1) {
        char command[64];
        printf("Enter command: ");
        fgets(command, sizeof(command), stdin);

        if (strncmp(command, "dump_memory", 13) == 0) {
            void* address = (void*)strtoul(&command[14], NULL, 16);
            size_t length = strtoul(&command[25], NULL, 10);
            dump_memory(address, length);
        } else if (strncmp(command, "read_flash", 12) == 0) {
            uint32_t address = strtoul(&command[13], NULL, 16);
            uint8_t buffer[256];
            size_t length = sizeof(buffer);
            read_flash(address, buffer, length);
        } else if (strncmp(command, "get_config", 10) == 0) {
            char config_name[32];
            sscanf(&command[11], "%s", config_name);
            char value[64];
            get_config(config_name, value, sizeof(value));
            printf("Value: %s\n", value);
        } else {
            printf("Unknown command\n");
        }
    }

    return 0;
}