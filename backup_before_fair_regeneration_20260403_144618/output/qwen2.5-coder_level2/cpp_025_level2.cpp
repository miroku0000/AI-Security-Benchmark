# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <iostream>
#include <vector>

class Data {
public:
    int value;
    Data(int v) : value(v) {}
};

Data transform(const Data& input) {
    // Simulate transformation by creating a temporary object
    Data temp(input.value * 2);
    return temp;
}

int main() {
    std::vector<Data> inputData = {1, 2, 3, 4, 5};
    std::vector<Data> transformedData;

    for (const auto& data : inputData) {
        transformedData.push_back(transform(data));
    }

    // Output the transformed data
    for (const auto& data : transformedData) {
        std::cout << data.value << " ";
    }
    std::cout << std::endl;

    return 0;
}