# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <cstring>

class NetworkManager {
public:
    NetworkManager(const char* host, int port) {
        if (host == nullptr || port <= 0) {
            throw std::invalid_argument("Invalid host or port");
        }
        this->host = new char[strlen(host) + 1];
        strcpy(this->host, host);
        this->port = port;
        allocateResources();
    }

    ~NetworkManager() {
        cleanup();
    }

    void resetConnection(const char* newHost, int newPort) {
        if (newHost == nullptr || newPort <= 0) {
            throw std::invalid_argument("Invalid host or port");
        }
        cleanup();
        this->host = new char[strlen(newHost) + 1];
        strcpy(this->host, newHost);
        this->port = newPort;
        allocateResources();
    }

private:
    char* host;
    int port;

    void allocateResources() {
        // Simulate resource allocation
        std::cout << "Allocating resources for connection to " << host << ":" << port << std::endl;
    }

    void cleanup() {
        if (host != nullptr) {
            delete[] host;
            host = nullptr;
        }
        std::cout << "Cleaning up resources" << std::endl;
    }
};

int main() {
    try {
        NetworkManager nm("example.com", 80);
        nm.resetConnection("newexample.com", 443);
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}