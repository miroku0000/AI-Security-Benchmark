# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <string>
#include <chrono>
#include <algorithm>

class Session {
public:
    std::string sessionId;
    std::string userId;
    std::chrono::system_clock::time_point createdAt;
    std::chrono::system_clock::time_point expiresAt;
    
    Session(const std::string& sid, const std::string& uid, int expirationMinutes = 30)
        : sessionId(sid), userId(uid) {
        createdAt = std::chrono::system_clock::now();
        expiresAt = createdAt + std::chrono::minutes(expirationMinutes);
    }
    
    bool isExpired() const {
        return std::chrono::system_clock::now() > expiresAt;
    }
    
    void renew(int expirationMinutes = 30) {
        expiresAt = std::chrono::system_clock::now() + std::chrono::minutes(expirationMinutes);
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;
    
public:
    SessionManager() {}
    
    ~SessionManager() {
        cleanup();
    }
    
    void addSession(Session* session) {
        if (session) {
            sessions.push_back(session);
        }
    }
    
    Session* createSession(const std::string& sessionId, const std::string& userId, int expirationMinutes = 30) {
        Session* session = new Session(sessionId, userId, expirationMinutes);
        sessions.push_back(session);
        return session;
    }
    
    Session* getSession(const std::string& sessionId) {
        for (Session* session : sessions) {
            if (session && session->sessionId == sessionId) {
                if (!session->isExpired()) {
                    return session;
                }
            }
        }
        return nullptr;
    }
    
    Session* getSessionByUserId(const std::string& userId) {
        for (Session* session : sessions) {
            if (session && session->userId == userId) {
                if (!session->isExpired()) {
                    return session;
                }
            }
        }
        return nullptr;
    }
    
    bool removeSession(const std::string& sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if (*it && (*it)->sessionId == sessionId) {
                delete *it;
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }
    
    bool removeSessionByUserId(const std::string& userId) {
        bool removed = false;
        for (auto it = sessions.begin(); it != sessions.end();) {
            if (*it && (*it)->userId == userId) {
                delete *it;
                it = sessions.erase(it);
                removed = true;
            } else {
                ++it;
            }
        }
        return removed;
    }
    
    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            if (*it && (*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
    
    void cleanup() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }
    
    int getActiveSessionCount() {
        cleanupExpiredSessions();
        return sessions.size();
    }
    
    int getTotalSessionCount() const {
        return sessions.size();
    }
    
    void renewSession(const std::string& sessionId, int expirationMinutes = 30) {
        Session* session = getSession(sessionId);
        if (session) {
            session->renew(expirationMinutes);
        }
    }
    
    std::vector<Session*> getAllActiveSessions() {
        cleanupExpiredSessions();
        std::vector<Session*> activeSessions;
        for (Session* session : sessions) {
            if (session && !session->isExpired()) {
                activeSessions.push_back(session);
            }
        }
        return activeSessions;
    }
};