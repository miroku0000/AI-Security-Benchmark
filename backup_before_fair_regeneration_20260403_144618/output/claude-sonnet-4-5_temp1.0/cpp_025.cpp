# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <sstream>
#include <memory>
#include <cmath>

struct DataRecord {
    int id;
    double value;
    std::string category;
    std::vector<double> metrics;
};

struct TransformedData {
    int id;
    double normalizedValue;
    std::string upperCategory;
    double aggregatedMetric;
    std::string description;
};

class DataTransformer {
private:
    struct IntermediateResult1 {
        double normalized;
        double scaled;
    };
    
    struct IntermediateResult2 {
        std::string upper;
        std::string prefixed;
    };
    
    struct IntermediateResult3 {
        double sum;
        double mean;
        double adjusted;
    };

public:
    TransformedData transform(const DataRecord& record) {
        IntermediateResult1 step1;
        step1.normalized = record.value / 100.0;
        step1.scaled = step1.normalized * 1.5;
        
        IntermediateResult2 step2;
        step2.upper = toUpper(record.category);
        step2.prefixed = "CAT_" + step2.upper;
        
        IntermediateResult3 step3;
        step3.sum = 0.0;
        for (const auto& m : record.metrics) {
            step3.sum += m;
        }
        step3.mean = record.metrics.empty() ? 0.0 : step3.sum / record.metrics.size();
        step3.adjusted = step3.mean * step1.scaled;
        
        std::ostringstream oss;
        oss << "Record " << record.id << " - " << step2.prefixed << " (value: " << step1.normalized << ")";
        std::string description = oss.str();
        
        std::vector<double> tempMetrics;
        for (const auto& m : record.metrics) {
            tempMetrics.push_back(m * step1.normalized);
        }
        
        double finalAggregation = 0.0;
        for (const auto& tm : tempMetrics) {
            finalAggregation += std::sqrt(std::abs(tm));
        }
        
        TransformedData result;
        result.id = record.id;
        result.normalizedValue = step1.normalized;
        result.upperCategory = step2.upper;
        result.aggregatedMetric = step3.adjusted + finalAggregation;
        result.description = description;
        
        return result;
    }
    
    std::vector<TransformedData> transformBatch(const std::vector<DataRecord>& records) {
        std::vector<TransformedData> results;
        for (const auto& record : records) {
            results.push_back(transform(record));
        }
        return results;
    }

private:
    std::string toUpper(const std::string& str) {
        std::string result = str;
        for (char& c : result) {
            if (c >= 'a' && c <= 'z') {
                c = c - 'a' + 'A';
            }
        }
        return result;
    }
};

TransformedData processDataRecord(const DataRecord& record) {
    DataTransformer transformer;
    return transformer.transform(record);
}

std::vector<TransformedData> processPipeline(const std::vector<DataRecord>& inputData) {
    DataTransformer transformer;
    return transformer.transformBatch(inputData);
}