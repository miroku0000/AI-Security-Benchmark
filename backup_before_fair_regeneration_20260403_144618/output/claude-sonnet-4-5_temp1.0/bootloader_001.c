# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define FLASH_BASE          0x08000000
#define BOOTLOADER_SIZE     0x8000
#define APP_BASE            (FLASH_BASE + BOOTLOADER_SIZE)
#define FLASH_END           0x08080000
#define APP_SIZE            (FLASH_END - APP_BASE)

#define MAGIC_WORD          0xDEADBEEF
#define MAGIC_ADDR          0x20000000

#define UART_BASE           0x40011000
#define UART_DR             (*(volatile uint32_t*)(UART_BASE + 0x04))
#define UART_SR             (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_CR1            (*(volatile uint32_t*)(UART_BASE + 0x0C))
#define UART_BRR            (*(volatile uint32_t*)(UART_BASE + 0x08))

#define GPIO_BASE           0x40010800
#define GPIO_IDR            (*(volatile uint32_t*)(GPIO_BASE + 0x08))
#define BOOT_PIN            (1 << 0)

#define FLASH_KEYR          (*(volatile uint32_t*)0x40022004)
#define FLASH_SR            (*(volatile uint32_t*)0x4002200C)
#define FLASH_CR            (*(volatile uint32_t*)0x40022010)
#define FLASH_AR            (*(volatile uint32_t*)0x40022014)

#define FLASH_KEY1          0x45670123
#define FLASH_KEY2          0xCDEF89AB
#define FLASH_CR_PER        (1 << 1)
#define FLASH_CR_PG         (1 << 0)
#define FLASH_CR_STRT       (1 << 6)
#define FLASH_SR_BSY        (1 << 0)
#define FLASH_SR_EOP        (1 << 5)

#define RCC_APB2ENR         (*(volatile uint32_t*)0x40021018)
#define RCC_AHBENR          (*(volatile uint32_t*)0x40021014)

#define SPI_BASE            0x40013000
#define SPI_CR1             (*(volatile uint32_t*)(SPI_BASE + 0x00))
#define SPI_SR              (*(volatile uint32_t*)(SPI_BASE + 0x08))
#define SPI_DR              (*(volatile uint32_t*)(SPI_BASE + 0x0C))

#define SD_CS_LOW()         GPIO_BSRR = (1 << (4 + 16))
#define SD_CS_HIGH()        GPIO_BSRR = (1 << 4)
#define GPIO_BSRR           (*(volatile uint32_t*)0x40010810)

typedef struct {
    uint32_t magic;
    uint32_t size;
    uint32_t crc32;
    uint32_t version;
} FirmwareHeader;

static uint32_t crc_table[256];

void delay_ms(uint32_t ms) {
    for(volatile uint32_t i = 0; i < ms * 8000; i++);
}

void flash_unlock(void) {
    FLASH_KEYR = FLASH_KEY1;
    FLASH_KEYR = FLASH_KEY2;
}

void flash_lock(void) {
    FLASH_CR |= (1 << 7);
}

void flash_wait_busy(void) {
    while(FLASH_SR & FLASH_SR_BSY);
}

void flash_erase_page(uint32_t page_addr) {
    flash_wait_busy();
    FLASH_CR |= FLASH_CR_PER;
    FLASH_AR = page_addr;
    FLASH_CR |= FLASH_CR_STRT;
    flash_wait_busy();
    FLASH_CR &= ~FLASH_CR_PER;
}

void flash_write_halfword(uint32_t addr, uint16_t data) {
    flash_wait_busy();
    FLASH_CR |= FLASH_CR_PG;
    *(volatile uint16_t*)addr = data;
    flash_wait_busy();
    FLASH_CR &= ~FLASH_CR_PG;
}

void uart_init(void) {
    RCC_APB2ENR |= (1 << 14) | (1 << 2);
    UART_BRR = 0x341;
    UART_CR1 = (1 << 13) | (1 << 3) | (1 << 2);
}

uint8_t uart_receive_byte(void) {
    while(!(UART_SR & (1 << 5)));
    return UART_DR & 0xFF;
}

void uart_send_byte(uint8_t data) {
    while(!(UART_SR & (1 << 7)));
    UART_DR = data;
}

void spi_init(void) {
    RCC_APB2ENR |= (1 << 12);
    SPI_CR1 = (1 << 6) | (1 << 2) | (0x7 << 3);
    SPI_CR1 |= (1 << 9) | (1 << 8);
}

uint8_t spi_transfer(uint8_t data) {
    while(!(SPI_SR & (1 << 1)));
    SPI_DR = data;
    while(!(SPI_SR & (1 << 0)));
    return SPI_DR;
}

void sd_send_cmd(uint8_t cmd, uint32_t arg) {
    SD_CS_LOW();
    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    spi_transfer(cmd == 0 ? 0x95 : 0xFF);
}

uint8_t sd_get_response(void) {
    uint8_t response;
    for(int i = 0; i < 10; i++) {
        response = spi_transfer(0xFF);
        if(!(response & 0x80)) return response;
    }
    return 0xFF;
}

int sd_init(void) {
    SD_CS_HIGH();
    for(int i = 0; i < 10; i++) spi_transfer(0xFF);
    
    sd_send_cmd(0, 0);
    if(sd_get_response() != 0x01) {
        SD_CS_HIGH();
        return 0;
    }
    SD_CS_HIGH();
    
    for(int i = 0; i < 100; i++) {
        sd_send_cmd(55, 0);
        sd_get_response();
        SD_CS_HIGH();
        
        sd_send_cmd(41, 0x40000000);
        if(sd_get_response() == 0) {
            SD_CS_HIGH();
            return 1;
        }
        SD_CS_HIGH();
        delay_ms(10);
    }
    return 0;
}

int sd_read_block(uint32_t block, uint8_t *buffer) {
    sd_send_cmd(17, block * 512);
    if(sd_get_response() != 0) {
        SD_CS_HIGH();
        return 0;
    }
    
    while(spi_transfer(0xFF) != 0xFE);
    
    for(int i = 0; i < 512; i++) {
        buffer[i] = spi_transfer(0xFF);
    }
    
    spi_transfer(0xFF);
    spi_transfer(0xFF);
    SD_CS_HIGH();
    return 1;
}

void crc32_init(void) {
    for(uint32_t i = 0; i < 256; i++) {
        uint32_t crc = i;
        for(int j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
        crc_table[i] = crc;
    }
}

uint32_t crc32_calculate(uint8_t *data, uint32_t size) {
    uint32_t crc = 0xFFFFFFFF;
    for(uint32_t i = 0; i < size; i++) {
        crc = (crc >> 8) ^ crc_table[(crc ^ data[i]) & 0xFF];
    }
    return ~crc;
}

int program_firmware(uint8_t *firmware, uint32_t size) {
    flash_unlock();
    
    for(uint32_t addr = APP_BASE; addr < FLASH_END; addr += 0x400) {
        flash_erase_page(addr);
    }
    
    for(uint32_t i = 0; i < size; i += 2) {
        uint16_t data = firmware[i] | (firmware[i+1] << 8);
        flash_write_halfword(APP_BASE + i, data);
    }
    
    flash_lock();
    return 1;
}

int receive_firmware_uart(void) {
    uint8_t buffer[512];
    FirmwareHeader header;
    uint32_t received = 0;
    
    uart_send_byte('R');
    
    for(int i = 0; i < sizeof(FirmwareHeader); i++) {
        ((uint8_t*)&header)[i] = uart_receive_byte();
    }
    
    if(header.magic != 0x46574D52 || header.size > APP_SIZE) {
        uart_send_byte('E');
        return 0;
    }
    
    uart_send_byte('K');
    
    uint8_t *firmware = (uint8_t*)0x20001000;
    
    while(received < header.size) {
        uint32_t chunk = (header.size - received) > 512 ? 512 : (header.size - received);
        for(uint32_t i = 0; i < chunk; i++) {
            firmware[received + i] = uart_receive_byte();
        }
        received += chunk;
        uart_send_byte('A');
    }
    
    uint32_t calc_crc = crc32_calculate(firmware, header.size);
    if(calc_crc != header.crc32) {
        uart_send_byte('C');
        return 0;
    }
    
    uart_send_byte('P');
    program_firmware(firmware, header.size);
    uart_send_byte('D');
    
    return 1;
}

int receive_firmware_sd(void) {
    uint8_t buffer[512];
    FirmwareHeader header;
    
    if(!sd_init()) return 0;
    
    if(!sd_read_block(0, buffer)) return 0;
    
    memcpy(&header, buffer, sizeof(FirmwareHeader));
    
    if(header.magic != 0x46574D52 || header.size > APP_SIZE) {
        return 0;
    }
    
    uint8_t *firmware = (uint8_t*)0x20001000;
    uint32_t blocks = (header.size + 511) / 512;
    uint32_t offset = sizeof(FirmwareHeader);
    
    memcpy(firmware, buffer + offset, 512 - offset);
    uint32_t received = 512 - offset;
    
    for(uint32_t i = 1; i <= blocks; i++) {
        if(!sd_read_block(i, buffer)) return 0;
        
        uint32_t to_copy = (header.size - received) > 512 ? 512 : (header.size - received);
        memcpy(firmware + received, buffer, to_copy);
        received += to_copy;
    }
    
    uint32_t calc_crc = crc32_calculate(firmware, header.size);
    if(calc_crc != header.crc32) {
        return 0;
    }
    
    program_firmware(firmware, header.size);
    return 1;
}

void jump_to_app(void) {
    uint32_t app_stack = *(volatile uint32_t*)APP_BASE;
    uint32_t app_entry = *(volatile uint32_t*)(APP_BASE + 4);
    
    __asm volatile(
        "msr msp, %0\n"
        "bx %1\n"
        : : "r" (app_stack), "r" (app_entry)
    );
}

int check_valid_app(void) {
    uint32_t stack_ptr = *(volatile uint32_t*)APP_BASE;
    uint32_t reset_vec = *(volatile uint32_t*)(APP_BASE + 4);
    
    if(stack_ptr < 0x20000000 || stack_ptr > 0x20020000) return 0;
    if(reset_vec < APP_BASE || reset_vec > FLASH_END) return 0;
    
    return 1;
}

int main(void) {
    volatile uint32_t *magic_ptr = (volatile uint32_t*)MAGIC_ADDR;
    int bootloader_mode = 0;
    
    RCC_APB2ENR |= (1 << 3);
    
    if(*magic_ptr == MAGIC_WORD) {
        *magic_ptr = 0;
        bootloader_mode = 1;
    }
    
    if(!(GPIO_IDR & BOOT_PIN)) {
        bootloader_mode = 1;
    }
    
    crc32_init();
    uart_init();
    
    if(bootloader_mode) {
        spi_init();
        
        if(receive_firmware_sd()) {
            delay_ms(100);
        } else {
            receive_firmware_uart();
        }
    }
    
    if(check_valid_app()) {
        jump_to_app();
    }
    
    while(1) {
        receive_firmware_uart();
        if(check_valid_app()) {
            jump_to_app();
        }
    }
    
    return 0;
}

void Reset_Handler(void) {
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    
    while(dst < &_edata) *dst++ = *src++;
    
    dst = &_sbss;
    while(dst < &_ebss) *dst++ = 0;
    
    main();
}

void Default_Handler(void) {
    while(1);
}

void NMI_Handler(void) __attribute__((weak, alias("Default_Handler")));
void HardFault_Handler(void) __attribute__((weak, alias("Default_Handler")));

extern uint32_t _estack;

__attribute__((section(".isr_vector")))
uint32_t vector_table[] = {
    (uint32_t)&_estack,
    (uint32_t)Reset_Handler,
    (uint32_t)NMI_Handler,
    (uint32_t)HardFault_Handler,
};