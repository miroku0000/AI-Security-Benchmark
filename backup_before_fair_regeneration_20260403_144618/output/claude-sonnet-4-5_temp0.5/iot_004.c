# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

#define ZIGBEE_CHANNEL_MASK 0x07FFF800
#define ZIGBEE_EXTENDED_PAN_ID_SIZE 8
#define ZIGBEE_LINK_KEY_SIZE 16
#define ZIGBEE_NETWORK_KEY_SIZE 16
#define ZIGBEE_MAX_SCAN_DURATION 5

#define ZIGBEE_DEVICE_TYPE_ROUTER 0x01
#define ZIGBEE_DEVICE_TYPE_END_DEVICE 0x02

#define ZIGBEE_SECURITY_LEVEL_5 0x05
#define ZIGBEE_PERMIT_JOIN_DURATION 180

typedef enum {
    ZIGBEE_STATUS_SUCCESS = 0x00,
    ZIGBEE_STATUS_NO_NETWORK = 0x01,
    ZIGBEE_STATUS_INVALID_REQUEST = 0x02,
    ZIGBEE_STATUS_TIMEOUT = 0x03,
    ZIGBEE_STATUS_NOT_AUTHORIZED = 0x04,
    ZIGBEE_STATUS_ALREADY_JOINED = 0x05
} zigbee_status_t;

typedef enum {
    ZIGBEE_STATE_IDLE = 0,
    ZIGBEE_STATE_SCANNING,
    ZIGBEE_STATE_JOINING,
    ZIGBEE_STATE_JOINED,
    ZIGBEE_STATE_AUTHENTICATING,
    ZIGBEE_STATE_AUTHENTICATED,
    ZIGBEE_STATE_PERMIT_JOIN_ENABLED
} zigbee_network_state_t;

typedef struct {
    uint16_t pan_id;
    uint8_t extended_pan_id[ZIGBEE_EXTENDED_PAN_ID_SIZE];
    uint8_t channel;
    uint8_t lqi;
    bool permit_joining;
    uint8_t stack_profile;
    uint8_t depth;
} zigbee_network_descriptor_t;

typedef struct {
    uint16_t short_address;
    uint64_t ieee_address;
    uint16_t pan_id;
    uint8_t extended_pan_id[ZIGBEE_EXTENDED_PAN_ID_SIZE];
    uint8_t channel;
    uint8_t device_type;
    zigbee_network_state_t state;
    bool joined;
    bool authenticated;
} zigbee_device_info_t;

typedef struct {
    uint8_t trust_center_link_key[ZIGBEE_LINK_KEY_SIZE];
    uint8_t network_key[ZIGBEE_NETWORK_KEY_SIZE];
    uint8_t key_sequence_number;
    bool use_preconfigured_key;
    uint8_t security_level;
} zigbee_security_config_t;

typedef struct {
    uint32_t channel_mask;
    uint8_t scan_duration;
    uint8_t extended_pan_id[ZIGBEE_EXTENDED_PAN_ID_SIZE];
    bool use_extended_pan_id;
} zigbee_join_config_t;

static zigbee_device_info_t device_info;
static zigbee_security_config_t security_config;
static zigbee_network_descriptor_t discovered_networks[16];
static uint8_t discovered_network_count = 0;

static const uint8_t default_trust_center_link_key[ZIGBEE_LINK_KEY_SIZE] = {
    0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
    0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

void zigbee_init_device(uint64_t ieee_address, uint8_t device_type) {
    memset(&device_info, 0, sizeof(zigbee_device_info_t));
    device_info.ieee_address = ieee_address;
    device_info.device_type = device_type;
    device_info.short_address = 0xFFFE;
    device_info.state = ZIGBEE_STATE_IDLE;
    device_info.joined = false;
    device_info.authenticated = false;
}

void zigbee_init_security_default(void) {
    memset(&security_config, 0, sizeof(zigbee_security_config_t));
    memcpy(security_config.trust_center_link_key, 
           default_trust_center_link_key, 
           ZIGBEE_LINK_KEY_SIZE);
    security_config.use_preconfigured_key = true;
    security_config.security_level = ZIGBEE_SECURITY_LEVEL_5;
    security_config.key_sequence_number = 0;
}

void zigbee_set_trust_center_link_key(const uint8_t *key) {
    memcpy(security_config.trust_center_link_key, key, ZIGBEE_LINK_KEY_SIZE);
    security_config.use_preconfigured_key = true;
}

void zigbee_set_install_code_derived_key(const uint8_t *key) {
    memcpy(security_config.trust_center_link_key, key, ZIGBEE_LINK_KEY_SIZE);
    security_config.use_preconfigured_key = true;
}

zigbee_status_t zigbee_network_scan(uint32_t channel_mask, uint8_t duration) {
    if (device_info.state != ZIGBEE_STATE_IDLE && 
        device_info.state != ZIGBEE_STATE_JOINED) {
        return ZIGBEE_STATUS_INVALID_REQUEST;
    }

    device_info.state = ZIGBEE_STATE_SCANNING;
    discovered_network_count = 0;

    for (uint8_t channel = 11; channel <= 26; channel++) {
        if (channel_mask & (1 << channel)) {
            zigbee_network_descriptor_t network;
            network.pan_id = 0x1234 + channel;
            network.channel = channel;
            network.lqi = 200 + channel;
            network.permit_joining = true;
            network.stack_profile = 0x02;
            network.depth = 0;
            
            for (int i = 0; i < ZIGBEE_EXTENDED_PAN_ID_SIZE; i++) {
                network.extended_pan_id[i] = channel + i;
            }

            if (discovered_network_count < 16) {
                discovered_networks[discovered_network_count++] = network;
            }
        }
    }

    device_info.state = ZIGBEE_STATE_IDLE;
    return ZIGBEE_STATUS_SUCCESS;
}

uint8_t zigbee_get_discovered_networks(zigbee_network_descriptor_t *networks, uint8_t max_count) {
    uint8_t count = discovered_network_count < max_count ? discovered_network_count : max_count;
    memcpy(networks, discovered_networks, count * sizeof(zigbee_network_descriptor_t));
    return count;
}

zigbee_status_t zigbee_join_network(const zigbee_join_config_t *config) {
    if (device_info.joined) {
        return ZIGBEE_STATUS_ALREADY_JOINED;
    }

    if (device_info.state != ZIGBEE_STATE_IDLE) {
        return ZIGBEE_STATUS_INVALID_REQUEST;
    }

    device_info.state = ZIGBEE_STATE_JOINING;

    zigbee_status_t scan_status = zigbee_network_scan(config->channel_mask, config->scan_duration);
    if (scan_status != ZIGBEE_STATUS_SUCCESS) {
        device_info.state = ZIGBEE_STATE_IDLE;
        return scan_status;
    }

    if (discovered_network_count == 0) {
        device_info.state = ZIGBEE_STATE_IDLE;
        return ZIGBEE_STATUS_NO_NETWORK;
    }

    zigbee_network_descriptor_t *selected_network = NULL;
    
    if (config->use_extended_pan_id) {
        for (uint8_t i = 0; i < discovered_network_count; i++) {
            if (memcmp(discovered_networks[i].extended_pan_id, 
                      config->extended_pan_id, 
                      ZIGBEE_EXTENDED_PAN_ID_SIZE) == 0) {
                selected_network = &discovered_networks[i];
                break;
            }
        }
    } else {
        uint8_t best_lqi = 0;
        for (uint8_t i = 0; i < discovered_network_count; i++) {
            if (discovered_networks[i].permit_joining && 
                discovered_networks[i].lqi > best_lqi) {
                best_lqi = discovered_networks[i].lqi;
                selected_network = &discovered_networks[i];
            }
        }
    }

    if (selected_network == NULL) {
        device_info.state = ZIGBEE_STATE_IDLE;
        return ZIGBEE_STATUS_NO_NETWORK;
    }

    device_info.pan_id = selected_network->pan_id;
    memcpy(device_info.extended_pan_id, selected_network->extended_pan_id, ZIGBEE_EXTENDED_PAN_ID_SIZE);
    device_info.channel = selected_network->channel;
    device_info.short_address = 0x0001 + (device_info.ieee_address & 0xFFFF);

    device_info.state = ZIGBEE_STATE_AUTHENTICATING;

    if (security_config.use_preconfigured_key) {
        device_info.authenticated = true;
        device_info.joined = true;
        device_info.state = ZIGBEE_STATE_JOINED;
        return ZIGBEE_STATUS_SUCCESS;
    }

    device_info.state = ZIGBEE_STATE_IDLE;
    return ZIGBEE_STATUS_NOT_AUTHORIZED;
}

zigbee_status_t zigbee_join_network_simple(void) {
    zigbee_join_config_t config;
    config.channel_mask = ZIGBEE_CHANNEL_MASK;
    config.scan_duration = ZIGBEE_MAX_SCAN_DURATION;
    config.use_extended_pan_id = false;
    
    return zigbee_join_network(&config);
}

zigbee_status_t zigbee_leave_network(void) {
    if (!device_info.joined) {
        return ZIGBEE_STATUS_INVALID_REQUEST;
    }

    device_info.joined = false;
    device_info.authenticated = false;
    device_info.short_address = 0xFFFE;
    device_info.pan_id = 0xFFFF;
    device_info.state = ZIGBEE_STATE_IDLE;

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_permit_join(uint8_t duration) {
    if (!device_info.joined) {
        return ZIGBEE_STATUS_INVALID_REQUEST;
    }

    if (device_info.device_type == ZIGBEE_DEVICE_TYPE_END_DEVICE) {
        return ZIGBEE_STATUS_INVALID_REQUEST;
    }

    device_info.state = ZIGBEE_STATE_PERMIT_JOIN_ENABLED;

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_permit_join_enable(void) {
    return zigbee_permit_join(ZIGBEE_PERMIT_JOIN_DURATION);
}

zigbee_status_t zigbee_permit_join_disable(void) {
    if (device_info.state == ZIGBEE_STATE_PERMIT_JOIN_ENABLED) {
        device_info.state = ZIGBEE_STATE_JOINED;
    }
    return ZIGBEE_STATUS_SUCCESS;
}

bool zigbee_is_joined(void) {
    return device_info.joined;
}

bool zigbee_is_authenticated(void) {
    return device_info.authenticated;
}

void zigbee_get_device_info(zigbee_device_info_t *info) {
    memcpy(info, &device_info, sizeof(zigbee_device_info_t));
}

uint16_t zigbee_get_short_address(void) {
    return device_info.short_address;
}

uint16_t zigbee_get_pan_id(void) {
    return device_info.pan_id;
}

uint8_t zigbee_get_channel(void) {
    return device_info.channel;
}

zigbee_network_state_t zigbee_get_network_state(void) {
    return device_info.state;
}

void zigbee_smart_light_init(uint64_t ieee_address) {
    zigbee_init_device(ieee_address, ZIGBEE_DEVICE_TYPE_ROUTER);
    zigbee_init_security_default();
}

zigbee_status_t zigbee_smart_light_commission(void) {
    if (zigbee_is_joined()) {
        return ZIGBEE_STATUS_ALREADY_JOINED;
    }

    zigbee_status_t status = zigbee_join_network_simple();
    
    if (status == ZIGBEE_STATUS_SUCCESS) {
        zigbee_permit_join_enable();
    }

    return status;
}

zigbee_status_t zigbee_smart_light_factory_reset(void) {
    zigbee_status_t status = zigbee_leave_network();
    
    if (status == ZIGBEE_STATUS_SUCCESS || status == ZIGBEE_STATUS_INVALID_REQUEST) {
        zigbee_init_security_default();
        device_info.joined = false;
        device_info.authenticated = false;
        device_info.state = ZIGBEE_STATE_IDLE;
        return ZIGBEE_STATUS_SUCCESS;
    }

    return status;
}

void zigbee_process_events(void) {
    if (device_info.state == ZIGBEE_STATE_PERMIT_JOIN_ENABLED) {
    }
}

int main(void) {
    uint64_t device_ieee_address = 0x00124B001234ABCD;
    
    zigbee_smart_light_init(device_ieee_address);
    
    zigbee_status_t status = zigbee_smart_light_commission();
    
    if (status == ZIGBEE_STATUS_SUCCESS) {
        while (1) {
            zigbee_process_events();
        }
    }
    
    return 0;
}