# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <cstring>
#include <sstream>

struct TransformResult {
    std::vector<double> normalized_data;
    std::string metadata;
    int status_code;
};

struct IntermediateData {
    std::vector<double> values;
    double sum;
    double mean;
    size_t count;
};

class DataTransformer {
private:
    struct ParsedInput {
        std::vector<double> raw_values;
        std::string source_id;
    };
    
    struct NormalizedData {
        std::vector<double> values;
        double min_val;
        double max_val;
    };
    
    struct EnrichedData {
        std::vector<double> values;
        std::string enriched_metadata;
    };

public:
    TransformResult transform_data(const std::vector<double>& input, const std::string& context) {
        ParsedInput parsed = parse_input(input, context);
        
        IntermediateData intermediate = compute_statistics(parsed);
        
        NormalizedData normalized = normalize_data(intermediate);
        
        EnrichedData enriched = enrich_metadata(normalized, context);
        
        TransformResult result = finalize_result(enriched);
        
        return result;
    }

private:
    ParsedInput parse_input(const std::vector<double>& input, const std::string& context) {
        ParsedInput parsed;
        parsed.raw_values = std::vector<double>(input.begin(), input.end());
        parsed.source_id = std::string("source_") + context;
        return parsed;
    }
    
    IntermediateData compute_statistics(const ParsedInput& parsed) {
        IntermediateData data;
        data.values = parsed.raw_values;
        data.count = parsed.raw_values.size();
        data.sum = 0.0;
        
        for (const auto& val : parsed.raw_values) {
            data.sum += val;
        }
        
        data.mean = data.count > 0 ? data.sum / data.count : 0.0;
        return data;
    }
    
    NormalizedData normalize_data(const IntermediateData& intermediate) {
        NormalizedData normalized;
        
        if (intermediate.values.empty()) {
            normalized.min_val = 0.0;
            normalized.max_val = 0.0;
            return normalized;
        }
        
        normalized.min_val = intermediate.values[0];
        normalized.max_val = intermediate.values[0];
        
        for (const auto& val : intermediate.values) {
            if (val < normalized.min_val) normalized.min_val = val;
            if (val > normalized.max_val) normalized.max_val = val;
        }
        
        double range = normalized.max_val - normalized.min_val;
        
        normalized.values.reserve(intermediate.values.size());
        for (const auto& val : intermediate.values) {
            if (range > 0.0) {
                normalized.values.push_back((val - normalized.min_val) / range);
            } else {
                normalized.values.push_back(0.0);
            }
        }
        
        return normalized;
    }
    
    EnrichedData enrich_metadata(const NormalizedData& normalized, const std::string& context) {
        EnrichedData enriched;
        enriched.values = normalized.values;
        
        std::ostringstream oss;
        oss << "context=" << context 
            << ";min=" << normalized.min_val 
            << ";max=" << normalized.max_val
            << ";count=" << normalized.values.size();
        enriched.enriched_metadata = oss.str();
        
        return enriched;
    }
    
    TransformResult finalize_result(const EnrichedData& enriched) {
        TransformResult result;
        result.normalized_data = enriched.values;
        result.metadata = enriched.enriched_metadata;
        result.status_code = enriched.values.empty() ? 1 : 0;
        return result;
    }
};

TransformResult process_data_hot_path(const std::vector<double>& input, const std::string& context) {
    DataTransformer transformer;
    return transformer.transform_data(input, context);
}