# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <sys/select.h>

#define PORT 8080
#define MAX_CONNECTIONS 100
#define BUFFER_SIZE 8192
#define MAX_HEADER_SIZE 4096
#define MAX_BODY_SIZE 1048576

typedef struct {
    char method[16];
    char uri[2048];
    char version[16];
    char headers[MAX_HEADER_SIZE];
    char *body;
    size_t body_length;
    size_t content_length;
} http_request_t;

typedef struct {
    int fd;
    char *buffer;
    size_t buffer_size;
    size_t buffer_used;
    int keep_alive;
} connection_t;

static connection_t connections[MAX_CONNECTIONS];

void init_connections() {
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        connections[i].fd = -1;
        connections[i].buffer = NULL;
        connections[i].buffer_size = 0;
        connections[i].buffer_used = 0;
        connections[i].keep_alive = 0;
    }
}

int find_free_connection() {
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        if (connections[i].fd == -1) {
            return i;
        }
    }
    return -1;
}

void close_connection(int idx) {
    if (connections[idx].fd != -1) {
        close(connections[idx].fd);
        connections[idx].fd = -1;
    }
    if (connections[idx].buffer) {
        free(connections[idx].buffer);
        connections[idx].buffer = NULL;
    }
    connections[idx].buffer_size = 0;
    connections[idx].buffer_used = 0;
    connections[idx].keep_alive = 0;
}

int parse_request_line(const char *line, http_request_t *req) {
    char *saveptr;
    char *line_copy = strdup(line);
    char *token;
    
    token = strtok_r(line_copy, " ", &saveptr);
    if (!token) {
        free(line_copy);
        return -1;
    }
    strncpy(req->method, token, sizeof(req->method) - 1);
    
    token = strtok_r(NULL, " ", &saveptr);
    if (!token) {
        free(line_copy);
        return -1;
    }
    strncpy(req->uri, token, sizeof(req->uri) - 1);
    
    token = strtok_r(NULL, "\r\n", &saveptr);
    if (!token) {
        free(line_copy);
        return -1;
    }
    strncpy(req->version, token, sizeof(req->version) - 1);
    
    free(line_copy);
    return 0;
}

int parse_http_request(const char *buffer, size_t len, http_request_t *req) {
    memset(req, 0, sizeof(http_request_t));
    
    const char *header_end = strstr(buffer, "\r\n\r\n");
    if (!header_end) {
        return -1;
    }
    
    size_t header_len = header_end - buffer;
    if (header_len > MAX_HEADER_SIZE - 1) {
        return -1;
    }
    
    const char *line_start = buffer;
    const char *line_end = strstr(line_start, "\r\n");
    if (!line_end) {
        return -1;
    }
    
    char request_line[2048];
    size_t request_line_len = line_end - line_start;
    if (request_line_len >= sizeof(request_line)) {
        return -1;
    }
    
    memcpy(request_line, line_start, request_line_len);
    request_line[request_line_len] = '\0';
    
    if (parse_request_line(request_line, req) < 0) {
        return -1;
    }
    
    line_start = line_end + 2;
    
    size_t headers_len = header_end - line_start;
    if (headers_len < MAX_HEADER_SIZE) {
        memcpy(req->headers, line_start, headers_len);
        req->headers[headers_len] = '\0';
    }
    
    const char *content_length_str = strstr(req->headers, "Content-Length:");
    if (content_length_str) {
        content_length_str += 15;
        while (*content_length_str == ' ') content_length_str++;
        req->content_length = atoi(content_length_str);
    }
    
    const char *body_start = header_end + 4;
    size_t body_available = len - (body_start - buffer);
    
    if (req->content_length > 0) {
        if (req->content_length > MAX_BODY_SIZE) {
            return -1;
        }
        
        if (body_available >= req->content_length) {
            req->body = malloc(req->content_length + 1);
            if (!req->body) {
                return -1;
            }
            memcpy(req->body, body_start, req->content_length);
            req->body[req->content_length] = '\0';
            req->body_length = req->content_length;
            return 0;
        } else {
            return -2;
        }
    }
    
    return 0;
}

void process_request(http_request_t *req, int client_fd) {
    char response[BUFFER_SIZE];
    char *response_body;
    size_t response_len;
    
    if (strcmp(req->method, "GET") == 0) {
        if (strcmp(req->uri, "/") == 0 || strcmp(req->uri, "/index.html") == 0) {
            response_body = "<html><body><h1>Welcome to Embedded Web Server</h1></body></html>";
            response_len = sprintf(response,
                "HTTP/1.1 200 OK\r\n"
                "Content-Type: text/html\r\n"
                "Content-Length: %zu\r\n"
                "Connection: keep-alive\r\n"
                "\r\n%s",
                strlen(response_body), response_body);
        } else if (strcmp(req->uri, "/status") == 0) {
            response_body = "{\"status\":\"running\",\"connections\":\"active\"}";
            response_len = sprintf(response,
                "HTTP/1.1 200 OK\r\n"
                "Content-Type: application/json\r\n"
                "Content-Length: %zu\r\n"
                "Connection: keep-alive\r\n"
                "\r\n%s",
                strlen(response_body), response_body);
        } else {
            response_body = "<html><body><h1>404 Not Found</h1></body></html>";
            response_len = sprintf(response,
                "HTTP/1.1 404 Not Found\r\n"
                "Content-Type: text/html\r\n"
                "Content-Length: %zu\r\n"
                "Connection: keep-alive\r\n"
                "\r\n%s",
                strlen(response_body), response_body);
        }
    } else if (strcmp(req->method, "POST") == 0) {
        response_body = "{\"status\":\"received\"}";
        response_len = sprintf(response,
            "HTTP/1.1 200 OK\r\n"
            "Content-Type: application/json\r\n"
            "Content-Length: %zu\r\n"
            "Connection: keep-alive\r\n"
            "\r\n%s",
            strlen(response_body), response_body);
    } else {
        response_body = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
        response_len = sprintf(response,
            "HTTP/1.1 405 Method Not Allowed\r\n"
            "Content-Type: text/html\r\n"
            "Content-Length: %zu\r\n"
            "Connection: close\r\n"
            "\r\n%s",
            strlen(response_body), response_body);
    }
    
    send(client_fd, response, response_len, 0);
}

void handle_connection(int idx) {
    connection_t *conn = &connections[idx];
    char temp_buffer[BUFFER_SIZE];
    
    ssize_t bytes_read = recv(conn->fd, temp_buffer, sizeof(temp_buffer), 0);
    
    if (bytes_read <= 0) {
        close_connection(idx);
        return;
    }
    
    size_t new_size = conn->buffer_used + bytes_read;
    if (new_size > conn->buffer_size) {
        size_t alloc_size = new_size + BUFFER_SIZE;
        char *new_buffer = realloc(conn->buffer, alloc_size);
        if (!new_buffer) {
            close_connection(idx);
            return;
        }
        conn->buffer = new_buffer;
        conn->buffer_size = alloc_size;
    }
    
    memcpy(conn->buffer + conn->buffer_used, temp_buffer, bytes_read);
    conn->buffer_used += bytes_read;
    
    while (1) {
        http_request_t req;
        int parse_result = parse_http_request(conn->buffer, conn->buffer_used, &req);
        
        if (parse_result == -2) {
            break;
        }
        
        if (parse_result < 0) {
            close_connection(idx);
            return;
        }
        
        process_request(&req, conn->fd);
        
        if (req.body) {
            free(req.body);
        }
        
        size_t request_total_size = strstr(conn->buffer, "\r\n\r\n") - conn->buffer + 4 + req.content_length;
        
        if (request_total_size < conn->buffer_used) {
            memmove(conn->buffer, conn->buffer + request_total_size, conn->buffer_used - request_total_size);
            conn->buffer_used -= request_total_size;
        } else {
            conn->buffer_used = 0;
            break;
        }
    }
}

int main() {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;
    
    init_connections();
    
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }
    
    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));
    
    fcntl(server_fd, F_SETFL, O_NONBLOCK);
    
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);
    
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }
    
    if (listen(server_fd, 10) < 0) {
        perror("listen failed");
        exit(EXIT_FAILURE);
    }
    
    printf("Server listening on port %d\n", PORT);
    
    while (1) {
        fd_set read_fds;
        int max_fd = server_fd;
        
        FD_ZERO(&read_fds);
        FD_SET(server_fd, &read_fds);
        
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].fd != -1) {
                FD_SET(connections[i].fd, &read_fds);
                if (connections[i].fd > max_fd) {
                    max_fd = connections[i].fd;
                }
            }
        }
        
        struct timeval timeout;
        timeout.tv_sec = 1;
        timeout.tv_usec = 0;
        
        int activity = select(max_fd + 1, &read_fds, NULL, NULL, &timeout);
        
        if (activity < 0 && errno != EINTR) {
            perror("select error");
            continue;
        }
        
        if (FD_ISSET(server_fd, &read_fds)) {
            struct sockaddr_in client_addr;
            socklen_t client_len = sizeof(client_addr);
            int client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
            
            if (client_fd >= 0) {
                fcntl(client_fd, F_SETFL, O_NONBLOCK);
                
                int idx = find_free_connection();
                if (idx >= 0) {
                    connections[idx].fd = client_fd;
                    connections[idx].buffer = malloc(BUFFER_SIZE);
                    connections[idx].buffer_size = BUFFER_SIZE;
                    connections[idx].buffer_used = 0;
                    connections[idx].keep_alive = 1;
                } else {
                    close(client_fd);
                }
            }
        }
        
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].fd != -1 && FD_ISSET(connections[i].fd, &read_fds)) {
                handle_connection(i);
            }
        }
    }
    
    close(server_fd);
    return 0;
}