# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

/* ============================================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update, GPIO/magic word entry
 * Target: Generic Cortex-M (STM32-like register layout)
 * ============================================================================ */

/* --------------------------------------------------------------------------
 * Memory Map Configuration
 * -------------------------------------------------------------------------- */
#define BOOTLOADER_BASE         0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader region */
#define APP_BASE                0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max application */
#define FLASH_PAGE_SIZE         2048
#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x20000         /* 128KB SRAM */

/* Magic value at fixed SRAM location to request bootloader entry */
#define BOOTLOADER_MAGIC_ADDR   ((volatile uint32_t *)(SRAM_BASE + SRAM_SIZE - 4))
#define BOOTLOADER_MAGIC_VALUE  0xDEADBEEF

/* Firmware header placed at beginning of binary */
#define FW_HEADER_MAGIC         0x464D5748      /* "FWMH" */
#define FW_HEADER_VERSION       1

/* --------------------------------------------------------------------------
 * Peripheral Base Addresses (STM32F4-like)
 * -------------------------------------------------------------------------- */
#define RCC_BASE                0x40023800
#define GPIOA_BASE              0x40020000
#define GPIOB_BASE              0x40020400
#define GPIOC_BASE              0x40020800
#define USART1_BASE             0x40011000
#define FLASH_R_BASE            0x40023C00
#define SDIO_BASE               0x40012C00
#define SCB_BASE                0xE000ED00
#define SYSTICK_BASE            0xE000E010
#define NVIC_BASE               0xE000E100

/* --------------------------------------------------------------------------
 * Register Definitions
 * -------------------------------------------------------------------------- */

/* RCC Registers */
#define RCC_CR          (*(volatile uint32_t *)(RCC_BASE + 0x00))
#define RCC_CFGR        (*(volatile uint32_t *)(RCC_BASE + 0x08))
#define RCC_AHB1ENR     (*(volatile uint32_t *)(RCC_BASE + 0x30))
#define RCC_APB1ENR     (*(volatile uint32_t *)(RCC_BASE + 0x40))
#define RCC_APB2ENR     (*(volatile uint32_t *)(RCC_BASE + 0x44))

/* GPIO Registers */
typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFRL;
    volatile uint32_t AFRH;
} GPIO_TypeDef;

#define GPIOA   ((GPIO_TypeDef *)GPIOA_BASE)
#define GPIOB   ((GPIO_TypeDef *)GPIOB_BASE)
#define GPIOC   ((GPIO_TypeDef *)GPIOC_BASE)

/* USART Registers */
typedef struct {
    volatile uint32_t SR;
    volatile uint32_t DR;
    volatile uint32_t BRR;
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t GTPR;
} USART_TypeDef;

#define USART1  ((USART_TypeDef *)USART1_BASE)

/* Flash Registers */
#define FLASH_ACR       (*(volatile uint32_t *)(FLASH_R_BASE + 0x00))
#define FLASH_KEYR      (*(volatile uint32_t *)(FLASH_R_BASE + 0x04))
#define FLASH_SR        (*(volatile uint32_t *)(FLASH_R_BASE + 0x0C))
#define FLASH_CR        (*(volatile uint32_t *)(FLASH_R_BASE + 0x10))

#define FLASH_KEY1      0x45670123
#define FLASH_KEY2      0xCDEF89AB

#define FLASH_SR_BSY    (1 << 16)
#define FLASH_SR_EOP    (1 << 0)
#define FLASH_CR_PG     (1 << 0)
#define FLASH_CR_SER    (1 << 1)
#define FLASH_CR_STRT   (1 << 16)
#define FLASH_CR_LOCK   (1 << 31)
#define FLASH_CR_SNB_SHIFT  3
#define FLASH_CR_PSIZE_SHIFT 8

/* SCB */
#define SCB_VTOR        (*(volatile uint32_t *)(SCB_BASE + 0x08))
#define SCB_AIRCR       (*(volatile uint32_t *)(SCB_BASE + 0x0C))

/* SysTick */
#define SYSTICK_CTRL    (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYSTICK_LOAD    (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYSTICK_VAL     (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

/* Bootloader GPIO pin: PC13 (common user button on many boards) */
#define BL_GPIO_PORT    GPIOC
#define BL_GPIO_PIN     13
#define BL_GPIO_RCC_BIT 2   /* Bit in AHB1ENR for GPIOC */

/* LED pin for status: PA5 */
#define LED_GPIO_PORT   GPIOA
#define LED_GPIO_PIN    5

/* UART config */
#define UART_BAUD_RATE  115200
#define UART_TIMEOUT_MS 5000
#define XMODEM_SOH      0x01
#define XMODEM_STX      0x02
#define XMODEM_EOT      0x04
#define XMODEM_ACK      0x06
#define XMODEM_NAK      0x15
#define XMODEM_CAN      0x18
#define XMODEM_C        0x43

/* --------------------------------------------------------------------------
 * Firmware Header Structure
 * -------------------------------------------------------------------------- */
typedef struct {
    uint32_t magic;             /* FW_HEADER_MAGIC */
    uint32_t header_version;
    uint32_t fw_version;
    uint32_t fw_size;           /* Size of firmware excluding header */
    uint32_t crc32;             /* CRC32 of firmware data */
    uint32_t entry_point;       /* Not used if vector table is standard */
    uint32_t reserved[2];
} fw_header_t;

/* --------------------------------------------------------------------------
 * SD Card (SPI Mode) Definitions
 * -------------------------------------------------------------------------- */
#define SD_SPI_PORT     GPIOB
#define SD_CS_PIN       12
#define SD_SCK_PIN      13
#define SD_MISO_PIN     14
#define SD_MOSI_PIN     15

/* Simplified FAT32 definitions */
#define SECTOR_SIZE             512
#define FAT32_SIGNATURE         0xAA55
#define FAT32_DIR_ENTRY_SIZE    32
#define FAT32_ATTR_ARCHIVE      0x20

/* SD Commands */
#define SD_CMD0     0
#define SD_CMD1     1
#define SD_CMD8     8
#define SD_CMD16    16
#define SD_CMD17    17
#define SD_CMD55    55
#define SD_ACMD41   41
#define SD_CMD58    58

/* --------------------------------------------------------------------------
 * Global Variables
 * -------------------------------------------------------------------------- */
static volatile uint32_t g_tick_ms = 0;
static uint8_t g_sector_buf[SECTOR_SIZE];
static uint8_t g_flash_buf[FLASH_PAGE_SIZE];
static bool g_sd_hc = false;   /* true if SDHC card */

/* CRC32 lookup table */
static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBB, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x4D11A686, 0x3A16968E, 0xAD1F6B12, 0xDA146484,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822, 0x3B6A6B51, 0x4C6D5BC7,
    0xD56A6A7D, 0xA26D1AEB, 0x346ED9FC, 0x4369E96A, 0xDA60B8D0, 0xAD678846,
    0x3B6A6B51, 0x4C6D5BC7, 0xD56A6A7D, 0xA26D1AEB, 0x9E6495A3, 0x0EDB8832,
    0x79DCB8A4, 0xE0D5E91B, 0x97D2D988, 0x09B64C2B, 0x7EB17CBB, 0xE7B82D09,
    0x90BF1D91, 0x1DB71064, 0x6AB020F2, 0xF3B97148, 0x84BE41DE, 0x1ADAD47D,
    0x6DDDE4EB, 0xF4D4B551, 0x83D385C7, 0x136C9856, 0x646BA8C0, 0xFD62F97A,
    0x8A65C9EC, 0x14015C4F, 0x63066CD9, 0xFA0F3D63, 0x8D080DF5, 0x4D11A686,
    0x3A16968E, 0xAD1F6B12, 0xDA146484, 0x6C0695ED, 0x1B01A57B, 0x8208F4C1,
    0xF50FC457, 0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF,
    0x15DA2D49, 0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE, 0xA3BC0074,
    0xD4BB30E2, 0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A,
    0x346ED9FC, 0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5, 0xAA0A4C5F,
    0xDD0D7822, 0x3B6A6B51, 0x4C6D5BC7, 0xD56A6A7D, 0xA26D1AEB, 0x9E6495A3,
    0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988, 0x09B64C2B, 0x7EB17CBB,
    0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2, 0xF3B97148, 0x84BE41DE,
    0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7, 0x136C9856, 0x646BA8C0,
    0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9, 0xFA0F3D63, 0x8D080DF5,
    0x4D11A686, 0x3A16968E, 0xAD1F6B12, 0xDA146484, 0x6C0695ED, 0x1B01A57B,
    0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C,
    0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE,
    0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4FB,
    0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5,
    0xAA0A4C5F, 0xDD0D7822, 0x3B6A6B51, 0x4C6D5BC7, 0xD56A6A7D, 0xA26D1AEB,
    0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988, 0x09B64C2B,
    0x7EB17CBB, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2, 0xF3B97148,
    0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7, 0x136C9856,
    0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9, 0xFA0F3D63,
    0x8D080DF5, 0x4D11A686, 0x3A16968E, 0xAD1F6B12, 0xDA146484, 0x6C0695ED,
    0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA,
    0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65, 0x4DB26158,
    0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7, 0xA4D1C46D,
    0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0, 0x44042D73,
    0x33031DE5, 0xAA0A4C5F, 0xDD0D7822
};

/* --------------------------------------------------------------------------
 * Forward Declarations
 * -------------------------------------------------------------------------- */
static void system_init(void);
static void systick_init(void);
static void gpio_init(void);
static void uart_init(void);
static void led_on(void);
static void led_off(void);
static void led_toggle(void);
static void delay_ms(uint32_t ms);
static uint32_t get_tick(void);

static bool check_bootloader_entry(void);
static bool check_valid_app(void);
static void jump_to_app(void);
static void system_deinit(void);

static void flash_unlock(void);
static void flash_lock(void);
static bool flash_erase_sector(uint32_t sector);
static bool flash_erase_app_area(void);
static bool flash_write_word(uint32_t address, uint32_t data);
static bool flash_write_buffer(uint32_t address, const uint8_t *data, uint32_t len);

static uint32_t crc32_compute(const uint8_t *data, uint32_t len);
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len);
static bool verify_firmware_header(const fw_header_t *hdr);
static bool verify_firmware_crc(uint32_t base_addr, uint32_t size, uint32_t expected_crc);

static void uart_send_byte(uint8_t b);
static void uart_send_string(const char *s);
static int uart_recv_byte(uint32_t timeout_ms);
static bool uart_receive_firmware(void);

static void spi_init(void);
static uint8_t spi_transfer(uint8_t data);
static void sd_cs_low(void);
static void sd_cs_high(void);
static bool sd_init(void);
static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg);
static bool sd_read_sector(uint32_t sector, uint8_t *buf);
static bool sd_check_and_update(void);

static uint32_t get_flash_sector(uint32_t address);

/* --------------------------------------------------------------------------
 * SysTick Handler
 * -------------------------------------------------------------------------- */
void SysTick_Handler(void) {
    g_tick_ms++;
}

/* --------------------------------------------------------------------------
 * System Initialization
 * -------------------------------------------------------------------------- */
static void system_init(void) {
    /* Enable HSI (internal 16MHz) - fast startup for bootloader */
    RCC_CR |= (1 << 0);  /* HSION */
    while (!(RCC_CR & (1 << 1)));  /* Wait for HSIRDY */

    /* Set flash latency for 16MHz */
    FLASH_ACR = (FLASH_ACR & ~0x0F) | 0x00;  /* 0 wait states at 16MHz */

    /* Use HSI as system clock */
    RCC_CFGR = (RCC_CFGR & ~0x03) | 0x00;  /* HSI selected */

    /* Enable GPIO clocks */
    RCC_AHB1ENR |= (1 << 0) | (1 << 1) | (1 << 2);  /* GPIOA, GPIOB, GPIOC */

    /* Enable USART1 clock */
    RCC_APB2ENR |= (1 << 4);  /* USART1EN */
}

static void systick_init(void) {
    /* Configure SysTick for 1ms at 16MHz */
    SYSTICK_LOAD = 16000 - 1;
    SYSTICK_VAL = 0;
    SYSTICK_CTRL = (1 << 2) | (1 << 1) | (1 << 0);  /* CLKSOURCE | TICKINT | ENABLE */
}

static void gpio_init(void) {
    /* Configure bootloader button pin (PC13) as input with pull-up */
    BL_GPIO_PORT->MODER &= ~(3 << (BL_GPIO_PIN * 2));     /* Input mode */
    BL_GPIO_PORT->PUPDR &= ~(3 << (BL_GPIO_PIN * 2));
    BL_GPIO_PORT->PUPDR |= (1 << (BL_GPIO_PIN * 2));       /* Pull-up */

    /* Configure LED pin (PA5) as output */
    LED_GPIO_PORT->MODER &= ~(3 << (LED_GPIO_PIN * 2));
    LED_GPIO_PORT->MODER |= (1 << (LED_GPIO_PIN * 2));     /* Output mode */
    LED_GPIO_PORT->OSPEEDR |= (3 << (LED_GPIO_PIN * 2));   /* High speed */
}

static void uart_init(void) {
    /* Configure PA9 (TX) and PA10 (RX) as alternate function (AF7 for USART1) */
    GPIOA->MODER &= ~((3 << (9 * 2)) | (3 << (10 * 2)));
    GPIOA->MODER |= (2 << (9 * 2)) | (2 << (10 * 2));     /* AF mode */
    GPIOA->AFRH &= ~((0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4)));
    GPIOA->AFRH |= (7 << ((9 - 8) * 4)) | (7 << ((10 - 8) * 4));  /* AF7 */

    /* Configure USART1: 115200 baud at 16MHz */
    USART1->CR1 = 0;
    USART1->BRR = (16000000 + UART_BAUD_RATE / 2) / UART_BAUD_RATE;
    USART1->CR1 = (1 << 13) | (1 << 3) | (1 << 2);  /* UE | TE | RE */
}

/* --------------------------------------------------------------------------
 * Utility Functions
 * -------------------------------------------------------------------------- */
static void led_on(void) {
    LED_GPIO_PORT->BSRR = (1 << LED_GPIO_PIN);
}

static void led_off(void) {
    LED_GPIO_PORT->BSRR = (1 << (LED_GPIO_PIN + 16));
}

static void led_toggle(void) {
    LED_GPIO_PORT->ODR ^= (1 << LED_GPIO_PIN);
}

static void delay_ms(uint32_t ms) {
    uint32_t start = g_tick_ms;
    while ((g_tick_ms - start) < ms);
}

static uint32_t get_tick(void) {
    return g_tick_ms;
}

/* --------------------------------------------------------------------------
 * UART Functions
 * -------------------------------------------------------------------------- */
static void uart_send_byte(uint8_t b) {
    while (!(USART1->SR & (1 << 7)));  /* Wait TXE */
    USART1->DR = b;
}

static void uart_send_string(const char *s) {
    while (*s) {
        uart_send_byte((uint8_t)*s++);
    }
}

static int uart_recv_byte(uint32_t timeout_ms) {
    uint32_t start = get_tick();
    while (!(USART1->SR & (1 << 5))) {  /* Wait RXNE */
        if ((get_tick() - start) >= timeout_ms) {
            return -1;  /* Timeout */
        }
    }
    return (int)(USART1->DR & 0xFF);
}

/* --------------------------------------------------------------------------
 * CRC32 Functions
 * -------------------------------------------------------------------------- */
static uint32_t crc32_compute(const uint8_t *data, uint32_t len) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < len; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFF;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len) {
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return ~crc;
}

/* --------------------------------------------------------------------------
 * Flash Operations
 * -------------------------------------------------------------------------- */
static uint32_t get_flash_sector(uint32_t address) {
    /* STM32F4 flash sector mapping */
    uint32_t offset = address - 0x08000000;
    if (offset < 0x4000) return 0;
    if (offset < 0x8000) return 1;
    if (offset < 0xC000) return 2;
    if (offset < 0x10000) return 3;
    if (offset < 0x20000) return 4;
    if (offset < 0x40000) return 5;
    if (offset < 0x60000) return 6;
    if (offset < 0x80000) return 7;
    return 0xFF;  /* Invalid */
}

static void flash_unlock(void) {
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void) {
    FLASH_CR |= FLASH_CR_LOCK;
}

static bool flash_erase_sector(uint32_t sector) {
    /* Wait for any ongoing operation */
    while (FLASH_SR & FLASH_SR_BSY);

    /* Clear any error flags */
    FLASH_SR = 0xF3;

    /* Set sector erase, sector number, and program size (32-bit) */
    FLASH_CR = FLASH_CR_SER | (sector << FLASH_CR_SNB_SHIFT) | (2 << FLASH_CR_PSIZE_SHIFT);
    FLASH_CR |= FLASH_CR_STRT;

    /* Wait for completion */
    while (FLASH_SR & FLASH_SR_BSY);

    /* Check for errors */
    if (FLASH_SR & 0xF2) {
        return false;
    }

    FLASH_CR &= ~FLASH_CR_SER;
    return true;
}

static bool flash_erase_app_area(void) {
    flash_unlock();

    /* Erase all sectors in the application area */
    uint32_t addr = APP_BASE;
    while (addr < (APP_BASE + APP_MAX_SIZE)) {
        uint32_t sector = get_flash_sector(addr);
        if (sector == 0xFF) break;

        led_toggle();

        if (!flash_erase_sector(sector)) {
            flash_lock();
            return false;
        }

        /* Advance to next sector */
        if (sector <= 3) addr += 0x4000;       /* 16KB sectors */
        else if (sector == 4) addr += 0x10000;  /* 64KB sector */
        else addr += 0x20000;                    /* 128KB sectors */
    }

    flash_lock();
    return true;
}

static bool flash_write_word(uint32_t address, uint32_t data) {
    while (FLASH_SR & FLASH_SR_BSY);

    FLASH_CR = FLASH_CR_PG | (2 << FLASH_CR_PSIZE_SHIFT);  /* 32-bit writes */

    *(volatile uint32_t *)address = data;

    while (FLASH_SR & FLASH_SR_BSY);

    FLASH_CR &= ~FLASH_CR_PG;

    if (*(volatile uint32_t *)address != data) {
        return false;
    }

    return true;
}

static bool flash_write_buffer(uint32_t address, const uint8_t *data, uint32_t len) {
    flash_unlock();

    /* Write 4 bytes at a time */
    uint32_t words = (len + 3) / 4;
    for (uint32_t i = 0; i < words; i++) {
        uint32_t word = 0xFFFFFFFF;
        uint32_t offset = i * 4;
        uint32_t remaining = len - offset;

        if (remaining >= 4) {
            memcpy(&word, &data[offset], 4);
        } else {
            memcpy(&word, &data[offset], remaining);
        }

        if (!flash_write_word(address + offset, word)) {
            flash_lock();
            return false;
        }
    }

    flash_lock();
    return true;
}

/* --------------------------------------------------------------------------
 * Firmware Verification
 * -------------------------------------------------------------------------- */
static bool verify_firmware_header(const fw_header_t *hdr) {
    if (hdr->magic != FW_HEADER_MAGIC) return false;
    if (hdr->header_version != FW_HEADER_VERSION) return false;
    if (hdr->fw_size == 0 || hdr->fw_size > APP_MAX_SIZE - sizeof(fw_header_t)) return false;
    return true;
}

static bool verify_firmware_crc(uint32_t base_addr, uint32_t size, uint32_t expected_crc) {
    uint32_t crc = 0xFFFFFFFF;
    const uint8_t *ptr = (const uint8_t *)base_addr;

    /* Process in chunks for progress indication */
    uint32_t chunk = 1024;
    uint32_t processed = 0;
    while (processed < size) {
        uint32_t remaining = size - processed;
        uint32_t to_process = (remaining < chunk) ? remaining : chunk;
        crc = ~crc;
        for (uint32_t i = 0; i < to_process; i++) {
            crc = crc32_table[(crc ^ ptr[processed + i]) & 0xFF] ^ (crc >> 8);
        }
        crc = ~crc;
        processed += to_process;
    }

    return (crc == expected_crc);
}

/* --------------------------------------------------------------------------
 * Application Validation and Jump
 * -------------------------------------------------------------------------- */
static bool check_valid_app(void) {
    uint32_t sp = *(volatile uint32_t *)APP_BASE;
    uint32_t pc = *(volatile uint32_t *)(APP_BASE + 4);

    /* Check if stack pointer is in SRAM range */
    if (sp < SRAM_BASE || sp > (SRAM_BASE + SRAM_SIZE)) {
        return false;
    }

    /* Check if reset vector is in flash range */
    if (pc < APP_BASE || pc > (APP_BASE + APP_MAX_SIZE)) {
        return false;
    }

    /* Optionally verify firmware header if present */
    const fw_header_t *hdr = (const fw_header_t *)(APP_BASE);
    if (hdr->magic == FW_HEADER_MAGIC) {
        /* Header present - full validation */
        if (!verify_firmware_header(hdr)) return false;
        /* CRC check on stored firmware */
        if (!verify_firmware_crc(APP_BASE + sizeof(fw_header_t),
                                  hdr->fw_size, hdr->crc32)) {
            return false;
        }
    }

    return true;
}

static void system_deinit(void) {
    /* Disable SysTick */
    SYSTICK_CTRL = 0;
    SYSTICK_LOAD = 0;
    SYSTICK_VAL = 0;

    /* Disable USART1 */
    USART1->CR1 = 0;

    /* Disable all NVIC interrupts */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(NVIC_BASE + 0x80 + i * 4) = 0xFFFFFFFF;  /* ICER */
    }
    /* Clear all pending interrupts */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(NVIC_BASE + 0x100 + i * 4) = 0xFFFFFFFF; /* ICPR */
    }

    /* Reset GPIO to default */
    LED_GPIO_PORT->MODER &= ~(3 << (LED_GPIO_PIN * 2));
}

static void jump_to_app(void) {
    typedef void (*app_entry_t)(void);

    uint32_t app_sp = *(volatile uint32_t *)APP_BASE;
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE + 4);

    system_deinit();

    /* Set vector table offset to application */
    SCB_VTOR = APP_BASE;

    /* Set main stack pointer */
    __asm volatile ("MSR msp, %0" : : "r" (app_sp));

    /* Memory barrier */
    __asm volatile ("DSB");
    __asm volatile ("ISB");

    /* Jump to application reset handler */
    app_entry_t app_entry = (app_entry_t)app_pc;
    app_entry();

    /* Should never reach here */
    while (1);
}

/* --------------------------------------------------------------------------
 * Bootloader Entry Check
 * -------------------------------------------------------------------------- */
static bool check_bootloader_entry(void) {
    /* Check 1: Magic value in SRAM */
    if (*BOOTLOADER_MAGIC_ADDR == BOOTLOADER_MAGIC_VALUE) {
        *BOOTLOADER_MAGIC_ADDR = 0;  /* Clear the flag */
        uart_send_string("BL: Magic word detected\r\n");
        return true;
    }

    /* Check 2: GPIO pin held low (button pressed) */
    /* Read pin multiple times for debounce */
    uint32_t low_count = 0;
    for (int i = 0; i < 100; i++) {
        if (!(BL_GPIO_PORT->IDR & (1 << BL_GPIO_PIN))) {
            low_count++;
        }
        /* Small delay */
        for (volatile int j = 0; j < 100; j++);
    }
    if (low_count > 80) {
        uart_send_string("BL: GPIO button detected\r\n");
        return true;
    }

    /* Check 3: No valid application */
    if (!check_valid_app()) {
        uart_send_string("BL: No valid app found\r\n");
        return true;
    }

    return false;
}

/* --------------------------------------------------------------------------
 * SPI Bit-Bang for SD Card (fast, no HAL dependency)
 * -------------------------------------------------------------------------- */
static void spi_init(void) {
    /* Configure SPI pins on GPIOB */
    /* CS (PB12): Output push-pull */
    SD_SPI_PORT->MODER &= ~(3 << (SD_CS_PIN * 2));
    SD_SPI_PORT->MODER |= (1 << (SD_CS_PIN * 2));
    SD_SPI_PORT->OSPEEDR |= (3 << (SD_CS_PIN * 2));

    /* SCK (PB13): Output push-pull */
    SD_SPI_PORT->MODER &= ~(3 << (SD_SCK_PIN * 2));
    SD_SPI_PORT->MODER |= (1 << (SD_SCK_PIN * 2));
    SD_SPI_PORT->OSPEEDR |= (3 << (SD_SCK_PIN * 2));

    /* MISO (PB14): Input with pull-up */
    SD_SPI_PORT->MODER &= ~(3 << (SD_MISO_PIN * 2));
    SD_SPI_PORT->PUPDR &= ~(3 << (SD_MISO_PIN * 2));
    SD_SPI_PORT->PUPDR |= (1 << (SD_MISO_PIN * 2));

    /* MOSI (PB15): Output push-pull */
    SD_SPI_PORT->MODER &= ~(3 << (SD_MOSI_PIN * 2));
    SD_SPI_PORT->MODER |= (1 << (SD_MOSI_PIN * 2));
    SD_SPI_PORT->OSPEEDR |= (3 << (SD_MOSI_PIN * 2));

    sd_cs_high();
    /* SCK idle low */
    SD_SPI_PORT->BSRR = (1 << (SD_SCK_PIN + 16));
}

static uint8_t spi_transfer(uint8_t data) {
    uint8_t result = 0;
    for (int i = 7; i >= 0; i--) {
        /* Set MOSI */
        if (data & (1 << i)) {
            SD_SPI_PORT->BSRR = (1 << SD_MOSI_PIN);
        } else {
            SD_SPI_PORT->BSRR = (1 << (SD_MOSI_PIN + 16));
        }

        /* SCK high */
        SD_SPI_PORT->BSRR = (1 << SD_SCK_PIN);

        /* Read MISO */
        if (SD_SPI_PORT->IDR & (1 << SD_MISO_PIN)) {
            result |= (1 << i);
        }

        /* SCK low */
        SD_SPI_PORT->BSRR = (1 << (SD_SCK_PIN + 16));
    }
    return result;
}

static void sd_cs_low(void) {
    SD_SPI_PORT->BSRR = (1 << (SD_CS_PIN + 16));
}

static void sd_cs_high(void) {
    SD_SPI_PORT->BSRR = (1 << SD_CS_PIN);
    spi_transfer(0xFF);  /* Extra clocks */
}

static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg) {
    uint8_t response;
    uint8_t crc = 0xFF;

    /* Precalculated CRCs for init commands */
    if (cmd == SD_CMD0) crc = 0x95;
    if (cmd == SD_CMD8) crc = 0x87;

    sd_cs_low();
    spi_transfer(0xFF);

    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    spi_transfer(crc);

    /* Wait for response (up to 8 bytes) */
    for (int i = 0; i < 10; i++) {
        response = spi_transfer(0xFF);
        if (!(response & 0x80)) break;
    }

    return response;
}

static bool sd_init(void) {
    uint8_t response;

    spi_init();

    /* Send 80+ clock pulses with CS high */
    sd_cs_high();
    for (int i = 0; i < 12; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0: GO_IDLE_STATE */
    response = sd_send_cmd(SD_CMD0, 0);
    sd_cs_high();
    if (response != 0x01) {
        return false;
    }

    /* CMD8: SEND_IF_COND (check for SDv2) */
    response = sd_send_cmd(SD_CMD8, 0x000001AA);
    if (response == 0x01) {
        /* SDv2 card */
        uint8_t r7[4];
        for (int i = 0; i < 4; i++) {
            r7[i] = spi_transfer(0xFF);
        }
        sd_cs_high();

        if (r7[2] != 0x01 || r7[3] != 0xAA) {
            return false;
        }

        /* ACMD41: Initialize */
        uint32_t start = get_tick();
        do {
            sd_send_cmd(SD_CMD55, 0);
            sd_cs_high();
            response = sd_send_cmd(SD_ACMD41, 0x40000000);  /* HCS bit */
            sd_cs_high();
            if ((get_tick() - start) > 2000) return false;
        } while (response != 0x00);

        /* CMD58: Read OCR to check CCS (card capacity) */
        response = sd_send_cmd(SD_CMD58, 0);
        if (response == 0x00) {
            uint8_t ocr[4];
            for (int i = 0; i < 4; i++) {
                ocr[i] = spi_transfer(0xFF);
            }
            g_sd_hc = (ocr[0] & 0x40) ? true : false;
        }
        sd_cs_high();
    } else {
        sd_cs_high();
        /* SDv1 or MMC */
        uint32_t start = get_tick();
        do {
            sd_send_cmd(SD_CMD55, 0);
            sd_cs_high();
            response = sd_send_cmd(SD_ACMD41, 0);
            sd_cs_high();
            if ((get_tick() - start) > 2000) return false;
        } while (response != 0x00);
        g_sd_hc = false;
    }

    /* Set block size to 512 for non-HC cards */
    if (!g_sd_hc) {
        response = sd_send_cmd(SD_CMD16, 512);
        sd_cs_high();
        if (response != 0x00) return false;
    }

    return true;
}

static bool sd_read_sector(uint32_t sector, uint8_t *buf) {
    uint32_t addr = g_sd_hc ? sector : (sector * 512);
    uint8_t response;

    response = sd_send_cmd(SD_CMD17, addr);
    if (response != 0x00) {
        sd_cs_high();
        return false;
    }

    /* Wait for data token (0xFE) */
    uint32_t start = get_tick();
    do {
        response = spi_transfer(0xFF);
        if ((get_tick() - start) > 500) {
            sd_cs_high();
            return false;
        }
    } while (response != 0xFE);

    /* Read 512 bytes */
    for (int i = 0; i < 512; i++) {
        buf[i] = spi_transfer(0xFF);
    }

    /* Read and discard CRC */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_cs_high();
    return true;
}

/* --------------------------------------------------------------------------
 * Simplified FAT32 - Find firmware.bin on SD card
 * -------------------------------------------------------------------------- */

typedef struct {
    uint32_t fat_start_sector;
    uint32_t data_start_sector;
    uint32_t root_cluster;
    uint32_t sectors_per_cluster;
    uint32_t bytes_per_sector;
} fat32_info_t;

static fat32_info_t g_fat;

static bool fat32_init(void) {
    /* Read MBR (sector 0) */
    if (!sd_read_sector(0, g_sector_buf)) return false;

    uint32_t partition_start = 0;

    /* Check for MBR */
    if (g_sector_buf[510] == 0x55 && g_sector_buf[511] == 0xAA) {
        /* Check if this is a BPB (no partition table) or MBR */
        if (g_sector_buf[0] == 0xEB || g_sector_buf[0] == 0xE9) {
            partition_start = 0;
        } else {
            /* Read partition start from MBR entry 0 */
            partition_start = *(uint32_t *)&g_sector_buf[454];
        }
    }

    /* Read BPB (BIOS Parameter Block) */
    if (partition_start != 0) {
        if (!sd_read_sector(partition_start, g_sector_buf)) return false;
    }

    /* Parse BPB */
    g_fat.bytes_per_sector = *(uint16_t *)&g_sector_buf[11];
    g_fat.sectors_per_cluster = g_sector_buf[13];
    uint16_t reserved_sectors = *(uint16_t *)&g_sector_buf[14];
    uint8_t num_fats = g_sector_buf[16];
    uint32_t fat_size = *(uint32_t *)&g_sector_buf[36];
    g_fat.root_cluster = *(uint32_t *)&g_sector_buf[44];

    if (g_fat.bytes_per_sector != 512 || g_fat.sectors_per_cluster == 0) {
        return false;
    }

    g_fat.fat_start_sector = partition_start + reserved_sectors;
    g_fat.data_start_sector = g_fat.fat_start_sector + (num_fats * fat_size);

    return true;
}

static uint32_t cluster_to_sector(uint32_t cluster) {
    return g_fat.data_start_sector + (cluster - 2) * g_fat.sectors_per_cluster;
}

static uint32_t fat32_next_cluster(uint32_t cluster) {
    uint32_t fat_offset = cluster * 4;
    uint32_t fat_sector = g_fat.fat_start_sector + (fat_offset / 512);
    uint32_t entry_offset = fat_offset % 512;

    if (!sd_read_sector(fat_sector, g_sector_buf)) return 0x0FFFFFFF;

    uint32_t next = *(uint32_t *)&g_sector_buf[entry_offset] & 0x0FFFFFFF;
    return next;
}

static bool fat32_find_file(const char *name_8_3, uint32_t *start_cluster, uint32_t *file_size) {
    uint32_t cluster = g_fat.root_cluster;

    while (cluster < 0x0FFFFFF8) {
        uint32_t sector = cluster_to_sector(cluster);

        for (uint32_t s = 0; s < g_fat.sectors_per_cluster; s++) {
            if (!sd_read_sector(sector + s, g_sector_buf)) return false;

            for (int e = 0; e < 16; e++) {  /* 16 entries per sector */
                uint8_t *entry = &g_sector_buf[e * 32];

                if (entry[0] == 0x00) return false;  /* End of directory */
                if (entry[0] == 0xE5) continue;      /* Deleted entry */
                if (entry[11] & 0x0F) continue;      /* LFN entry */

                /* Compare 8.3 filename */
                if (memcmp(entry, name_8_3, 11) == 0) {
                    *start_cluster = ((uint32_t)*(uint16_t *)&entry[20] << 16) |
                                     *(uint16_t *)&entry[26];
                    *file_size = *(uint32_t *)&entry[28];
                    return true;
                }
            }
        }

        cluster = fat32_next_cluster(cluster);
    }

    return false;
}

/* --------------------------------------------------------------------------
 * SD Card Firmware Update
 * -------------------------------------------------------------------------- */
static bool sd_check_and_update(void) {
    uart_send_string("BL: Checking SD card...\r\n");

    if (!sd_init()) {
        uart_send_string("BL: SD init failed\r\n");
        return false;
    }

    uart_send_string("BL: SD card detected\r\n");

    if (!fat32_init()) {
        uart_send_string("BL: FAT32 init failed\r\n");
        return false;
    }

    /* Look for "FIRMWARE.BIN" (8.3 format: "FIRMWAREBIN") */
    uint32_t file_cluster, file_size;
    /* 8.3 name padded: "FIRMWARE" + "BIN" */
    if (!fat32_find_file("FIRMWAREBIN", &file_cluster, &file_size)) {
        uart_send_string("BL: No firmware file found\r\n");
        return false;
    }

    uart_send_string("BL: Firmware file found, size: ");
    /* Print size (simple hex output) */
    char hex[12];
    uint32_t val = file_size;
    for (int i = 7; i >= 0; i--) {
        uint8_t nibble = val & 0xF;
        hex[i] = nibble < 10 ? ('0' + nibble) : ('A' + nibble - 10);
        val >>= 4;
    }
    hex[8] = '\r';
    hex[9] = '\n';
    hex[10] = 0;
    uart_send_string(hex);

    if (file_size < sizeof(fw_header_t) || file_size > APP_MAX_SIZE) {
        uart_send_string("BL: Invalid firmware size\r\n");
        return false;
    }

    /* Read and verify header first */
    uint32_t sector = cluster_to_sector(file_cluster);
    if (!sd_read_sector(sector, g_sector_buf)) {
        uart_send_string("BL: Read error\r\n");
        return false;
    }

    fw_header_t *hdr = (fw_header_t *)g_sector_buf;
    if (!verify_firmware_header(hdr)) {
        uart_send_string("BL: Invalid firmware header\r\n");
        return false;
    }

    /* Check if this is a newer version than currently installed */
    const fw_header_t *current_hdr = (const fw_header_t *)APP_BASE;
    if (current_hdr->magic == FW_HEADER_MAGIC &&
        current_hdr->fw_version >= hdr->fw_version) {
        uart_send_string("BL: Firmware is not newer, skipping\r\n");
        return false;
    }

    uint32_t expected_crc = hdr->crc32;
    uint32_t fw_total_size = file_size;

    uart_send_string("BL: Erasing flash...\r\n");
    if (!flash_erase_app_area()) {
        uart_send_string("BL: Flash erase failed!\r\n");
        return false;
    }

    uart_send_string("BL: Programming flash...\r\n");

    /* Read file from SD and write to flash */
    uint32_t cluster_cur = file_cluster;
    uint32_t bytes_written = 0;
    uint32_t flash_addr = APP_BASE;

    while (bytes_written < fw_total_size && cluster_cur < 0x0FFFFFF8) {
        uint32_t sec = cluster_to_sector(cluster_cur);

        for (uint32_t s = 0; s < g_fat.sectors_per_cluster && bytes_written < fw_total_size; s++) {
            if (!sd_read_sector(sec + s, g_sector_buf)) {
                uart_send_string("BL: SD read error during programming\r\n");
                return false;
            }

            uint32_t to_write = fw_total_size - bytes_written;
            if (to_write > SECTOR_SIZE) to_write = SECTOR_SIZE;

            if (!flash_write_buffer(flash_addr, g_sector_buf, to_write)) {
                uart_send_string("BL: Flash write error!\r\n");
                return false;
            }

            flash_addr += to_write;
            bytes_written += to_write;
            led_toggle();
        }

        cluster_cur = fat32_next_cluster(cluster_cur);
    }

    if (bytes_written != fw_total_size) {
        uart_send_string("BL: Incomplete firmware transfer\r\n");
        return false;
    }

    /* Verify CRC of written firmware (skip header, check payload) */
    uart_send_string("BL: Verifying CRC...\r\n");
    if (!verify_firmware_crc(APP_BASE + sizeof(fw_header_t),
                              hdr->fw_size, expected_crc)) {
        uart_send_string("BL: CRC verification failed!\r\n");
        /* Erase corrupted firmware */
        flash_erase_app_area();
        return false;
    }

    uart_send_string("BL: SD firmware update successful!\r\n");
    led_on();
    return true;
}

/* --------------------------------------------------------------------------
 * UART Firmware Update (XMODEM-CRC Protocol)
 * -------------------------------------------------------------------------- */
static uint16_t xmodem_crc16(const uint8_t *data, uint32_t len) {
    uint16_t crc = 0;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (int j = 0; j < 8; j++) {
            if (crc & 0x8000)
                crc = (crc << 1) ^ 0x1021;
            else
                crc <<= 1;
        }
    }
    return crc;
}

static bool uart_receive_firmware(void) {
    uart_send_string("BL: UART update mode\r\n");
    uart_send_string("BL: Send firmware via XMODEM-CRC...\r\n");

    uint8_t packet_buf[1024 + 5];  /* Max: STX + seq + ~seq + 1024 data + 2 CRC */
    uint32_t flash_addr = APP_BASE;
    uint32_t total_received = 0;
    uint8_t expected_seq = 1;
    bool first_packet = true;
    fw_header_t fw_hdr;
    bool header_valid = false;
    bool erased = false;

    /* Send 'C' to initiate XMODEM-CRC */
    int retries = 60;  /* 60 seconds timeout to start */
    int byte;

    while (retries > 0) {
        uart_send_byte(XMODEM_C);
        byte = uart_recv_byte(1000);
        if (byte == XMODEM_SOH || byte == XMODEM_STX) {
            break;
        }
        retries--;
        led_toggle();
    }

    if (retries == 0) {
        uart_send_string("BL: XMODEM timeout\r\n");
        return false;
    }

    while (1) {
        uint32_t packet_size;

        if (byte == XMODEM_SOH) {
            packet_size = 128;
        } else if (byte == XMODEM_STX) {
            packet_size = 1024;
        } else if (byte == XMODEM_EOT) {
            /* End of transmission */
            uart_send_byte(XMODEM_ACK);
            break;
        } else if (byte == XMODEM_CAN) {
            uart_send_string("BL: Transfer cancelled\r\n");
            return false;
        } else {
            /* Unexpected byte, NAK and retry */
            uart_send_byte(XMODEM_NAK);
            byte = uart_recv_byte(10000);
            if (byte < 0) return false;
            continue;
        }

        /* Read sequence number */
        int seq = uart_recv_byte(1000);
        if (seq < 0) { uart_send_byte(XMODEM_NAK); continue; }

        int seq_comp = uart_recv_byte(1000);
        if (seq_comp < 0) { uart_send_byte(XMODEM_NAK); continue; }

        /* Read data */
        bool read_ok = true;
        for (uint32_t i = 0; i < packet_size; i++) {
            int d = uart_recv_byte(1000);
            if (d < 0) { read_ok = false; break; }
            packet_buf[i] = (uint8_t)d;
        }
        if (!read_ok) { uart_send_byte(XMODEM_NAK); continue; }

        /* Read CRC16 */
        int crc_hi = uart_recv_byte(1000);
        int crc_lo = uart_recv_byte(1000);
        if (crc_hi < 0 || crc_lo < 0) { uart_send_byte(XMODEM_NAK); continue; }

        /* Verify sequence number */
        if ((uint8_t)seq != expected_seq || (uint8_t)(seq + seq_comp) != 0xFF) {
            /* Could be duplicate - if previous seq, just ACK */
            if ((uint8_t)seq == (uint8_t)(expected_seq - 1)) {
                uart_send_byte(XMODEM_ACK);
            } else {
                uart_send_byte(XMODEM_NAK);
            }
            byte = uart_recv_byte(10000);
            if (byte < 0) return false;
            continue;
        }

        /* Verify CRC */
        uint16_t received_crc = ((uint16_t)crc_hi << 8) | (uint16_t)crc_lo;
        uint16_t computed_crc = xmodem_crc16(packet_buf, packet_size);
        if (received_crc != computed_crc) {
            uart_send_byte(XMODEM_NAK);
            byte = uart_recv_byte(10000);
            if (byte < 0) return false;
            continue;
        }

        /* First packet: validate header and erase flash */
        if (first_packet) {
            memcpy(&fw_hdr, packet_buf, sizeof(fw_header_t));
            if (verify_firmware_header(&fw_hdr)) {
                header_valid = true;
            }

            uart_send_string("BL: Erasing flash...\r\n");
            if (!flash_erase_app_area()) {
                uart_send_byte(XMODEM_CAN);
                uart_send_byte(XMODEM_CAN);
                uart_send_string("BL: Flash erase failed!\r\n");
                return false;
            }
            erased = true;
            first_packet = false;
        }

        /* Write to flash */
        if (!flash_write_buffer(flash_addr, packet_buf, packet_size)) {
            uart_send_byte(XMODEM_CAN);
            uart_send_byte(XMODEM_CAN);
            uart_send_string("BL: Flash write error!\r\n");
            return false;
        }

        flash_addr += packet_size;
        total_received += packet_size;
        expected_seq++;

        uart_send_byte(XMODEM_ACK);
        led_toggle();

        /* Wait for next packet header */
        byte = uart_recv_byte(10000);
        if (byte < 0) {
            uart_send_string("BL: Timeout waiting for next packet\r\n");
            return false;
        }
    }

    uart_send_string("BL: Transfer complete. Received bytes: ");
    char hex[12];
    uint32_t val = total_received;
    for (int i = 7; i >= 0; i--) {
        uint8_t nibble = val & 0xF;
        hex[i] = nibble < 10 ? ('0' + nibble) : ('A' + nibble - 10);
        val >>= 4;
    }
    hex[8] = '\r';
    hex[9] = '\n';
    hex[10] = 0;
    uart_send_string(hex);

    /* Verify if header was valid */
    if (header_valid) {
        uart_send_string("BL: Verifying CRC...\r\n");
        if (!verify_firmware_crc(APP_BASE + sizeof(fw_header_t),
                                  fw_hdr.fw_size, fw_hdr.crc32)) {
            uart_send_string("BL: CRC verification FAILED!\r\n");
            flash_erase_app_area();
            return false;
        }
        uart_send_string("BL: CRC OK\r\n");
    } else {
        uart_send_string("BL: Warning: No firmware header, skipping CRC check\r\n");
    }

    uart_send_string("BL: UART firmware update successful!\r\n");
    return