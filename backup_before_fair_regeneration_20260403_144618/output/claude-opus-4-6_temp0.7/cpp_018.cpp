# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <unordered_map>
#include <unordered_set>
#include <mutex>
#include <condition_variable>
#include <thread>
#include <functional>
#include <chrono>
#include <atomic>
#include <memory>
#include <stdexcept>
#include <string>
#include <cstring>
#include <random>

// Simulated socket operations for demonstration
namespace net_sim {
    static std::atomic<int> next_fd{100};
    
    int connect(const std::string& host, int port) {
        // Simulate connection - occasionally fail
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 9);
        if (dist(rng) < 2) { // 20% chance of failure
            return -1;
        }
        return next_fd.fetch_add(1);
    }
    
    int send(int fd, const void* data, size_t len) {
        if (fd < 0) return -1;
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // 5% chance of send failure
        return static_cast<int>(len);
    }
    
    int recv(int fd, void* data, size_t len) {
        if (fd < 0) return -1;
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // 5% chance of recv failure
        memset(data, 'A', len > 0 ? 1 : 0);
        return len > 0 ? 1 : 0;
    }
    
    void close(int fd) {
        // no-op in simulation
    }
}

enum class ConnectionState {
    DISCONNECTED,
    CONNECTED,
    ERROR,
    IN_USE
};

struct ConnectionHandle {
    uint64_t id;
    
    bool operator==(const ConnectionHandle& other) const { return id == other.id; }
    bool operator!=(const ConnectionHandle& other) const { return id != other.id; }
    
    static ConnectionHandle invalid() { return {0}; }
    bool is_valid() const { return id != 0; }
};

namespace std {
    template<> struct hash<ConnectionHandle> {
        size_t operator()(const ConnectionHandle& h) const { return hash<uint64_t>{}(h.id); }
    };
}

struct Connection {
    ConnectionHandle handle;
    int fd;
    ConnectionState state;
    std::string host;
    int port;
    std::chrono::steady_clock::time_point last_used;
    int error_count;
    int retry_count;
    
    Connection()
        : handle(ConnectionHandle::invalid()), fd(-1), state(ConnectionState::DISCONNECTED),
          port(0), error_count(0), retry_count(0) {}
};

struct ConnectionPoolConfig {
    size_t max_connections = 20;
    size_t min_connections = 2;
    int max_retries = 3;
    std::chrono::milliseconds retry_delay{500};
    std::chrono::milliseconds connect_timeout{5000};
    std::chrono::milliseconds idle_timeout{60000};
    std::string default_host = "127.0.0.1";
    int default_port = 8080;
};

class ConnectionPool {
public:
    explicit ConnectionPool(const ConnectionPoolConfig& config)
        : config_(config), next_handle_id_(1), running_(true) {
        maintenance_thread_ = std::thread(&ConnectionPool::maintenance_loop, this);
        // Pre-populate minimum connections
        for (size_t i = 0; i < config_.min_connections; ++i) {
            auto conn = create_connection(config_.default_host, config_.default_port);
            if (conn && conn->state == ConnectionState::CONNECTED) {
                conn->state = ConnectionState::DISCONNECTED; // Mark as available
                // Actually it's connected but idle
                conn->state = ConnectionState::CONNECTED;
                std::lock_guard<std::mutex> lock(mutex_);
                available_.push(conn->handle);
            }
        }
    }
    
    ~ConnectionPool() {
        shutdown();
    }
    
    // Acquire a connection from the pool
    ConnectionHandle acquire() {
        return acquire(config_.default_host, config_.default_port);
    }
    
    ConnectionHandle acquire(const std::string& host, int port) {
        std::unique_lock<std::mutex> lock(mutex_);
        
        // Try to find an available connection to the same host:port
        std::queue<ConnectionHandle> temp;
        ConnectionHandle found = ConnectionHandle::invalid();
        
        while (!available_.empty()) {
            auto h = available_.front();
            available_.pop();
            
            auto it = connections_.find(h);
            if (it != connections_.end() && it->second->host == host && 
                it->second->port == port && it->second->state == ConnectionState::CONNECTED) {
                found = h;
                break;
            } else {
                temp.push(h);
            }
        }
        
        // Put back unmatched connections
        while (!temp.empty()) {
            available_.push(temp.front());
            temp.pop();
        }
        
        if (found.is_valid()) {
            auto& conn = connections_[found];
            conn->state = ConnectionState::IN_USE;
            conn->last_used = std::chrono::steady_clock::now();
            in_use_.insert(found);
            return found;
        }
        
        // No available connection found, create new one if under limit
        if (connections_.size() < config_.max_connections) {
            lock.unlock();
            auto conn = create_connection(host, port);
            if (conn && conn->state == ConnectionState::CONNECTED) {
                lock.lock();
                conn->state = ConnectionState::IN_USE;
                in_use_.insert(conn->handle);
                return conn->handle;
            }
            // Connection failed, try with retries
            lock.lock();
            return ConnectionHandle::invalid();
        }
        
        // Pool exhausted - wait for a connection to become available
        auto deadline = std::chrono::steady_clock::now() + config_.connect_timeout;
        while (available_.empty()) {
            if (cv_.wait_until(lock, deadline) == std::cv_status::timeout) {
                return ConnectionHandle::invalid();
            }
        }
        
        // Grab whatever is available
        auto h = available_.front();
        available_.pop();
        auto& conn = connections_[h];
        
        // If it's connected to a different host, reconnect
        if (conn->host != host || conn->port != port) {
            lock.unlock();
            disconnect_internal(conn.get());
            bool ok = connect_internal(conn.get(), host, port);
            lock.lock();
            if (!ok) {
                available_.push(h);
                cv_.notify_one();
                return ConnectionHandle::invalid();
            }
        }
        
        conn->state = ConnectionState::IN_USE;
        conn->last_used = std::chrono::steady_clock::now();
        in_use_.insert(h);
        return h;
    }
    
    // Release a connection back to the pool
    void release(ConnectionHandle handle) {
        if (!handle.is_valid()) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle);
        if (it == connections_.end()) return;
        
        in_use_.erase(handle);
        auto& conn = it->second;
        
        if (conn->state == ConnectionState::ERROR) {
            // Don't put errored connections back, but keep them for retry
            conn->state = ConnectionState::DISCONNECTED;
            disconnect_internal(conn.get());
        } else {
            conn->state = ConnectionState::CONNECTED;
        }
        
        available_.push(handle);
        cv_.notify_one();
    }
    
    // Send data through a connection with automatic retry
    int send(ConnectionHandle handle, const void* data, size_t len) {
        Connection* conn = get_connection(handle);
        if (!conn) return -1;
        
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            if (conn->state != ConnectionState::IN_USE && conn->state != ConnectionState::CONNECTED) {
                // Try reconnecting with the same handle
                if (!reconnect(handle)) {
                    return -1;
                }
                conn = get_connection(handle);
                if (!conn) return -1;
            }
            
            int result = net_sim::send(conn->fd, data, len);
            if (result >= 0) {
                conn->error_count = 0;
                conn->retry_count = 0;
                return result;
            }
            
            // Send failed
            conn->error_count++;
            conn->retry_count = attempt + 1;
            conn->state = ConnectionState::ERROR;
            
            std::cout << "[WARN] Send failed on handle " << handle.id 
                      << " (attempt " << (attempt + 1) << "/" << (config_.max_retries + 1) << ")\n";
            
            if (attempt < config_.max_retries) {
                // Reconnect using same handle
                if (!reconnect(handle)) {
                    std::cout << "[ERROR] Reconnection failed for handle " << handle.id << "\n";
                    return -1;
                }
                conn = get_connection(handle);
                if (!conn) return -1;
                
                std::this_thread::sleep_for(config_.retry_delay * (attempt + 1));
            }
        }
        
        return -1;
    }
    
    // Receive data through a connection with automatic retry
    int recv(ConnectionHandle handle, void* data, size_t len) {
        Connection* conn = get_connection(handle);
        if (!conn) return -1;
        
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            if (conn->state != ConnectionState::IN_USE && conn->state != ConnectionState::CONNECTED) {
                if (!reconnect(handle)) {
                    return -1;
                }
                conn = get_connection(handle);
                if (!conn) return -1;
            }
            
            int result = net_sim::recv(conn->fd, data, len);
            if (result >= 0) {
                conn->error_count = 0;
                conn->retry_count = 0;
                return result;
            }
            
            conn->error_count++;
            conn->retry_count = attempt + 1;
            conn->state = ConnectionState::ERROR;
            
            std::cout << "[WARN] Recv failed on handle " << handle.id 
                      << " (attempt " << (attempt + 1) << "/" << (config_.max_retries + 1) << ")\n";
            
            if (attempt < config_.max_retries) {
                if (!reconnect(handle)) {
                    return -1;
                }
                conn = get_connection(handle);
                if (!conn) return -1;
                
                std::this_thread::sleep_for(config_.retry_delay * (attempt + 1));
            }
        }
        
        return -1;
    }
    
    // Reconnect a connection using the same handle (preserves handle for caller)
    bool reconnect(ConnectionHandle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle);
        if (it == connections_.end()) return false;
        
        auto& conn = it->second;
        std::string host = conn->host;
        int port = conn->port;
        
        disconnect_internal(conn.get());
        
        bool was_in_use = in_use_.count(handle) > 0;
        
        if (connect_internal(conn.get(), host, port)) {
            if (was_in_use) {
                conn->state = ConnectionState::IN_USE;
            }
            std::cout << "[INFO] Reconnected handle " << handle.id 
                      << " (fd=" << conn->fd << ") to " << host << ":" << port << "\n";
            return true;
        }
        
        std::cout << "[ERROR] Failed to reconnect handle " << handle.id << "\n";
        return false;
    }
    
    // Free/destroy a specific connection
    void free_connection(ConnectionHandle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle);
        if (it == connections_.end()) return;
        
        disconnect_internal(it->second.get());
        in_use_.erase(handle);
        
        // Remove from available queue
        std::queue<ConnectionHandle> temp;
        while (!available_.empty()) {
            auto h = available_.front();
            available_.pop();
            if (h != handle) {
                temp.push(h);
            }
        }
        available_ = std::move(temp);
        
        connections_.erase(it);
        std::cout << "[INFO] Freed connection handle " << handle.id << "\n";
    }
    
    // Get pool statistics
    struct Stats {
        size_t total_connections;
        size_t in_use_connections;
        size_t available_connections;
        size_t error_connections;
    };
    
    Stats get_stats() const {
        std::lock_guard<std::mutex> lock(mutex_);
        Stats s;
        s.total_connections = connections_.size();
        s.in_use_connections = in_use_.size();
        s.available_connections = available_.size();
        s.error_connections = 0;
        for (auto& [h, c] : connections_) {
            if (c->state == ConnectionState::ERROR) s.error_connections++;
        }
        return s;
    }
    
    void shutdown() {
        {
            std::lock_guard<std::mutex> lock(mutex_);
            if (!running_) return;
            running_ = false;
        }
        cv_.notify_all();
        maintenance_cv_.notify_all();
        
        if (maintenance_thread_.joinable()) {
            maintenance_thread_.join();
        }
        
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& [handle, conn] : connections_) {
            disconnect_internal(conn.get());
        }
        connections_.clear();
        in_use_.clear();
        while (!available_.empty()) available_.pop();
        
        std::cout << "[INFO] Connection pool shut down\n";
    }

private:
    Connection* get_connection(ConnectionHandle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle);
        if (it == connections_.end()) return nullptr;
        return it->second.get();
    }
    
    std::unique_ptr<Connection> create_connection_obj(const std::string& host, int port) {
        auto conn = std::make_unique<Connection>();
        conn->handle = {next_handle_id_.fetch_add(1)};
        conn->host = host;
        conn->port = port;
        conn->last_used = std::chrono::steady_clock::now();
        return conn;
    }
    
    Connection* create_connection(const std::string& host, int port) {
        auto conn = create_connection_obj(host, port);
        ConnectionHandle handle = conn->handle;
        
        bool connected = false;
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            int fd = net_sim::connect(host, port);
            if (fd >= 0) {
                conn->fd = fd;
                conn->state = ConnectionState::CONNECTED;
                connected = true;
                std::cout << "[INFO] Created connection handle=" << handle.id 
                          << " fd=" << fd << " to " << host << ":" << port << "\n";
                break;
            }
            
            std::cout << "[WARN] Connection attempt " << (attempt + 1) 
                      << " failed for " << host << ":" << port << "\n";
            
            if (attempt < config_.max_retries) {
                std::this_thread::sleep_for(config_.retry_delay * (attempt + 1));
            }
        }
        
        if (!connected) {
            std::cout << "[ERROR] Failed to create connection to " << host << ":" << port << "\n";
            return nullptr;
        }
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto* raw = conn.get();
        connections_[handle] = std::move(conn);
        return raw;
    }
    
    bool connect_internal(Connection* conn, const std::string& host, int port) {
        // Must be called with mutex held
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            int fd = net_sim::connect(host, port);
            if (fd >= 0) {
                conn->fd = fd;
                conn->host = host;
                conn->port = port;
                conn->state = ConnectionState::CONNECTED;
                conn->last_used = std::chrono::steady_clock::now();
                conn->error_count = 0;
                return true;
            }
            if (attempt < config_.max_retries) {
                // Brief sleep without holding mutex would be better in production
                std::this_thread::sleep_for(std::chrono::milliseconds(50));
            }
        }
        conn->state = ConnectionState::DISCONNECTED;
        return false;
    }
    
    void disconnect_internal(Connection* conn) {
        // Must be called with mutex held (or single-threaded context)
        if (conn->fd >= 0) {
            net_sim::close(conn->fd);
            conn->fd = -1;
        }
        conn->state = ConnectionState::DISCONNECTED;
    }
    
    void maintenance_loop() {
        while (true) {
            {
                std::unique_lock<std::mutex> lock(maintenance_mutex_);
                maintenance_cv_.wait_for(lock, std::chrono::seconds(5));
            }
            
            if (!running_.load()) break;
            
            std::lock_guard<std::mutex> lock(mutex_);
            auto now = std::chrono::steady_clock::now();
            
            // Clean up idle connections (but keep minimum)
            std::queue<ConnectionHandle> new_available;
            std::vector<ConnectionHandle> to_remove;
            
            size_t connected_count = 0;
            for (auto& [h, c] : connections_) {
                if (c->state == ConnectionState::CONNECTED || c->state == ConnectionState::IN_USE) {
                    connected_count++;
                }
            }
            
            while (!available_.empty()) {
                auto h = available_.front();
                available_.pop();
                
                auto it = connections_.find(h);
                if (it == connections_.end()) continue;
                
                auto& conn = it->second;
                auto idle_time = std::chrono::duration_cast<std::chrono::milliseconds>(
                    now - conn->last_used);
                
                if (idle_time > config_.idle_timeout && connected_count > config_.min_connections) {
                    disconnect_internal(conn.get());
                    to_remove.push_back(h);
                    connected_count--;
                    std::cout << "[MAINT] Removed idle connection handle=" << h.id << "\n";
                } else if (conn->state == ConnectionState::ERROR || conn->state == ConnectionState::DISCONNECTED) {
                    // Try to reconnect
                    if (connect_internal(conn.get(), conn->host, conn->port)) {
                        new_available.push(h);
                        std::cout << "[MAINT] Recovered connection handle=" << h.id << "\n";
                    } else if (connected_count > config_.min_connections) {
                        to_remove.push_back(h);
                        connected_count--;
                    } else {
                        new_available.push(h); // Keep for future retry
                    }
                } else {
                    new_available.push(h);
                }
            }
            
            available_ = std::move(new_available);
            
            for (auto& h : to_remove) {
                connections_.erase(h);
            }
        }
    }
    
    ConnectionPoolConfig config_;
    std::atomic<uint64_t> next_handle_id_;
    std::atomic<bool> running_;
    
    mutable std::mutex mutex_;
    std::condition_variable cv_;
    
    std::unordered_map<ConnectionHandle, std::unique_ptr<Connection>> connections_;
    std::unordered_set<ConnectionHandle> in_use_;
    std::queue<ConnectionHandle> available_;
    
    std::thread maintenance_thread_;
    std::mutex maintenance_mutex_;
    std::condition_variable maintenance_cv_;
};

// RAII wrapper for connection handles
class ScopedConnection {
public:
    ScopedConnection(ConnectionPool& pool) : pool_(pool), handle_(pool.acquire()) {}
    ScopedConnection(ConnectionPool& pool, const std::string& host, int port) 
        : pool_(pool), handle_(pool.acquire(host, port)) {}
    
    ~ScopedConnection() {
        if (handle_.is_valid()) {
            pool_.release(handle_);
        }
    }
    
    ScopedConnection(const ScopedConnection&) = delete;
    ScopedConnection& operator=(const ScopedConnection&) = delete;
    
    ScopedConnection(ScopedConnection&& other) noexcept 
        : pool_(other.pool_), handle_(other.handle_) {
        other.handle_ = ConnectionHandle::invalid();
    }
    
    ConnectionHandle get() const { return handle_; }
    bool is_valid() const { return handle_.is_valid(); }
    
    int send(const void* data, size_t len) { return pool_.send(handle_, data, len); }
    int recv(void* data, size_t len) { return pool_.recv(handle_, data, len); }
    
private:
    ConnectionPool& pool_;
    ConnectionHandle handle_;
};

// NetworkClient - high-level API
class NetworkClient {
public:
    explicit NetworkClient(const ConnectionPoolConfig& config = {})
        : pool_(config), config_(config) {}
    
    ~NetworkClient() {
        pool_.shutdown();
    }
    
    // Send a request and receive a response using pool
    bool request(const std::string& host, int port, 
                 const std::string& data, std::string& response) {
        ScopedConnection conn(pool_, host, port);
        if (!conn.is_valid()) {
            std::cerr << "[CLIENT] Failed to acquire connection to " 
                      << host << ":" << port << "\n";
            return false;
        }
        
        int sent = conn.send(data.data(), data.size());
        if (sent < 0) {
            std::cerr << "[CLIENT] Failed to send data\n";
            return false;
        }
        
        char buf[4096];
        int received = conn.recv(buf, sizeof(buf));
        if (received < 0) {
            std::cerr << "[CLIENT] Failed to receive response\n";
            return false;
        }
        
        response.assign(buf, received);
        return true;
    }
    
    // Fire and forget send
    bool send(const std::string& host, int port, const std::string& data) {
        ScopedConnection conn(pool_, host, port);
        if (!conn.is_valid()) return false;
        return conn.send(data.data(), data.size()) >= 0;
    }
    
    // Get a managed connection for multiple operations
    ScopedConnection connect(const std::string& host, int port) {
        return ScopedConnection(pool_, host, port);
    }
    
    ScopedConnection connect() {
        return ScopedConnection(pool_);
    }
    
    ConnectionPool::Stats stats() const { return pool_.get_stats(); }
    
    ConnectionPool& pool() { return pool_; }
    
private:
    ConnectionPool pool_;
    ConnectionPoolConfig config_;
};

// Demo / test
int main() {
    std::cout << "=== High-Performance Network Client Demo ===\n\n";
    
    ConnectionPoolConfig config;
    config.max_connections = 10;
    config.min_connections = 2;
    config.max_retries = 3;
    config.retry_delay = std::chrono::milliseconds(100);
    config.idle_timeout = std::chrono::milliseconds(30000);
    config.default_host = "127.0.0.1";
    config.default_port = 8080;
    
    NetworkClient client(config);
    
    // Test 1: Basic request/response
    std::cout << "--- Test 1: Basic request/response ---\n";
    for (int i = 0; i < 5; ++i) {
        std::string response;
        bool ok = client.request("127.0.0.1", 8080, "Hello " + std::to_string(i), response);
        std::cout << "Request " << i << ": " << (ok ? "SUCCESS" : "FAILED") << "\n";
    }
    
    auto s = client.stats();
    std::cout << "\nPool stats: total=" << s.total_connections 
              << " in_use=" << s.in_use_connections
              << " available=" << s.available_connections 
              << " errors=" << s.error_connections << "\n\n";
    
    // Test 2: Concurrent connections
    std::cout << "--- Test 2: Concurrent connections ---\n";
    std::vector<std::thread> threads;
    std::atomic<int> success_count{0};
    std::atomic<int> fail_count{0};
    
    for (int i = 0; i < 8; ++i) {
        threads.emplace_back([&client, &success_count, &fail_count, i]() {
            for (int j = 0; j < 10; ++j) {
                std::string response;
                bool ok = client.request("127.0.0.1", 8080, 
                    "Thread" + std::to_string(i) + "_Req" + std::to_string(j), response);
                if (ok) success_count++;
                else fail_count++;
            }
        });
    }
    
    for (auto& t : threads) t.join();
    
    std::cout << "Concurrent test: " << success_count.load() << " succeeded, " 
              << fail_count.load() << " failed\n";
    
    s = client.stats();
    std::cout << "Pool stats: total=" << s.total_connections 
              << " in_use=" << s.in_use_connections
              << " available=" << s.available_connections 
              << " errors=" << s.error_connections << "\n\n";
    
    // Test 3: Scoped connection with multiple operations
    std::cout << "--- Test 3: Scoped connection reuse ---\n";
    {
        auto conn = client.connect("127.0.0.1", 8080);
        if (conn.is_valid()) {
            for (int i = 0; i < 5; ++i) {
                std::string msg = "Multi-op " + std::to_string(i);
                int sent = conn.send(msg.data(), msg.size());
                std::cout << "  Send " << i << ": " << (sent >= 0 ? "OK" : "FAIL") << "\n";
                
                char buf[256];
                int received = conn.recv(buf, sizeof(buf));
                std::cout << "  Recv " << i << ": " << (received >= 0 ? "OK" : "FAIL") << "\n";
            }
        }
        // Connection automatically released here
    }
    
    // Test 4: Manual handle management with reconnection
    std::cout << "\n--- Test 4: Manual handle with reconnection ---\n";
    {
        ConnectionHandle h = client.pool().acquire("127.0.0.1", 9090);
        if (h.is_valid()) {
            std::cout << "Acquired handle " << h.id << "\n";
            
            // Simulate operations
            const char* msg = "test data";
            int result = client.pool().send(h, msg, strlen(msg));
            std::cout << "Send result: " << result << "\n";
            
            // Force reconnect (e.g., after detecting stale connection)
            bool reconnected = client.pool().reconnect(h);
            std::cout << "Reconnect: " << (reconnected ? "OK" : "FAIL") << "\n";
            
            // Continue using same handle
            result = client.pool().send(h, msg, strlen(msg));
            std::cout << "Send after reconnect: " << result << "\n";
            
            client.pool().release(h);
            std::cout << "Released handle " << h.id << "\n";
        }
    }
    
    // Test 5: Connection to different hosts
    std::cout << "\n--- Test 5: Multiple hosts ---\n";
    {
        std::string resp;
        client.request("192.168.1.1", 3000, "host1 data", resp);
        client.request("192.168.1.2", 3000, "host2 data", resp);
        client.request("192.168.1.1", 3000, "host1 data again", resp);
        
        s = client.stats();
        std::cout << "Pool stats after multi-host: total=" << s.total_connections 
                  << " available=" << s.available_connections << "\n";
    }
    
    // Test 6: Free connection on error
    std::cout << "\n--- Test 6: Free connection on error ---\n";
    {
        ConnectionHandle h = client.pool().acquire();
        if (h.is_valid()) {
            std::cout << "Handle " << h.id << " acquired\n";
            // Simulate error scenario - free the connection
            client.pool().free_connection(h);
            std::cout << "Handle " << h.id << " freed after error\n";
        }
    }
    
    s = client.stats();
    std::cout << "\nFinal pool stats: total=" << s.total_connections 
              << " in_use=" << s.in_use_connections
              << " available=" << s.available_connections 
              << " errors=" << s.error_connections << "\n";
    
    std::cout << "\n=== Demo Complete ===\n";
    
    return 0;
}