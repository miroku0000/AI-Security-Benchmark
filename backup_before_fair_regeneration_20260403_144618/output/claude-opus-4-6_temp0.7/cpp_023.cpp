# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int port;
    int max_threads;
    bool help_requested;
} Config;

void print_usage(const char *program_name) {
    printf("Usage: %s [options]\n", program_name);
    printf("Options:\n");
    printf("  -i, --input <file>      Input file path\n");
    printf("  -o, --output <file>     Output file path\n");
    printf("  -v, --verbose           Enable verbose output\n");
    printf("  -p, --port <number>     Port number (default: 8080)\n");
    printf("  -t, --threads <number>  Max threads (default: 4)\n");
    printf("  -h, --help              Show this help message\n");
}

Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 1 || argv == NULL) {
        fprintf(stderr, "Error: Invalid arguments\n");
        return NULL;
    }

    Config *config = (Config *)calloc(1, sizeof(Config));
    if (config == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration\n");
        return NULL;
    }

    /* Set defaults */
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    config->max_threads = 4;
    config->help_requested = false;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help_requested = true;
            return config;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --input requires a file path argument\n");
                free(config);
                return NULL;
            }
            i++;
            config->input_file = strdup(argv[i]);
            if (config->input_file == NULL) {
                fprintf(stderr, "Error: Failed to allocate memory for input file path\n");
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --output requires a file path argument\n");
                free(config->input_file);
                free(config);
                return NULL;
            }
            i++;
            config->output_file = strdup(argv[i]);
            if (config->output_file == NULL) {
                fprintf(stderr, "Error: Failed to allocate memory for output file path\n");
                free(config->input_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --port requires a number argument\n");
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
            i++;
            char *endptr;
            long port = strtol(argv[i], &endptr, 10);
            if (*endptr != '\0' || port < 1 || port > 65535) {
                fprintf(stderr, "Error: Invalid port number '%s' (must be 1-65535)\n", argv[i]);
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
            config->port = (int)port;
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --threads requires a number argument\n");
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
            i++;
            char *endptr;
            long threads = strtol(argv[i], &endptr, 10);
            if (*endptr != '\0' || threads < 1 || threads > 256) {
                fprintf(stderr, "Error: Invalid thread count '%s' (must be 1-256)\n", argv[i]);
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
            config->max_threads = (int)threads;
        } else {
            fprintf(stderr, "Error: Unknown option '%s'\n", argv[i]);
            free(config->input_file);
            free(config->output_file);
            free(config);
            return NULL;
        }
    }

    return config;
}

void config_free(Config *config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config);
    }
}

int initialize_application(Config *config) {
    if (config == NULL) {
        fprintf(stderr, "Error: Cannot initialize application with NULL configuration\n");
        return -1;
    }

    if (config->help_requested) {
        return 0;
    }

    printf("=== Application Initialization ===\n");
    printf("  Input file:   %s\n", config->input_file ? config->input_file : "(none)");
    printf("  Output file:  %s\n", config->output_file ? config->output_file : "(none)");
    printf("  Port:         %d\n", config->port);
    printf("  Max threads:  %d\n", config->max_threads);
    printf("  Verbose:      %s\n", config->verbose ? "enabled" : "disabled");
    printf("==================================\n");

    if (config->verbose) {
        printf("[VERBOSE] Application initialized successfully.\n");
    }

    return 0;
}

int main(int argc, char *argv[]) {
    /* Parse arguments and immediately use the returned pointer to initialize */
    Config *config = parse_arguments(argc, argv);

    if (config == NULL) {
        print_usage(argv[0]);
        return EXIT_FAILURE;
    }

    if (config->help_requested) {
        print_usage(argv[0]);
        config_free(config);
        return EXIT_SUCCESS;
    }

    int result = initialize_application(config);
    if (result != 0) {
        fprintf(stderr, "Error: Application initialization failed\n");
        config_free(config);
        return EXIT_FAILURE;
    }

    /* --- Main application logic would go here --- */
    printf("Application is running...\n");

    /* Cleanup */
    config_free(config);
    return EXIT_SUCCESS;
}