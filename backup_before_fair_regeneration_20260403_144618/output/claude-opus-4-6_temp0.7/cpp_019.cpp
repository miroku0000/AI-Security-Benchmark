# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_KEY_LEN 128
#define MAX_VALUE_LEN 512
#define DEFAULT_TTL 3600  /* 1 hour in seconds */

typedef struct SessionDataEntry {
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
    struct SessionDataEntry *next;
} SessionDataEntry;

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED,
    SESSION_INVALIDATED
} SessionStatus;

typedef struct {
    char session_id[SESSION_ID_LEN];
    SessionDataEntry *data;
    time_t created_at;
    time_t last_accessed;
    time_t expires_at;
    int ttl;
    SessionStatus status;
    bool slot_used;
} Session;

typedef struct {
    Session sessions[MAX_SESSIONS];
    int active_count;
    int cached_id_count;
} SessionCache;

/* Forward declarations */
static unsigned int hash_session_id(const char *session_id);
static void generate_session_id(char *buffer, size_t len);
static void free_session_data(SessionDataEntry *data);
static Session *find_session_slot(SessionCache *cache, const char *session_id);
static void check_and_expire_session(Session *session);

/* Initialize the session cache */
SessionCache *cache_create(void) {
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        fprintf(stderr, "Failed to allocate session cache\n");
        return NULL;
    }
    cache->active_count = 0;
    cache->cached_id_count = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache->sessions[i].slot_used = false;
        cache->sessions[i].data = NULL;
        cache->sessions[i].status = SESSION_INVALIDATED;
    }
    return cache;
}

/* Destroy the entire cache */
void cache_destroy(SessionCache *cache) {
    if (!cache) return;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            free_session_data(cache->sessions[i].data);
            cache->sessions[i].data = NULL;
        }
    }
    free(cache);
}

/* Hash function for session IDs */
static unsigned int hash_session_id(const char *session_id) {
    unsigned int hash = 5381;
    int c;
    while ((c = *session_id++)) {
        hash = ((hash << 5) + hash) + c;
    }
    return hash % MAX_SESSIONS;
}

/* Generate a pseudo-random session ID */
static void generate_session_id(char *buffer, size_t len) {
    static const char charset[] = "abcdefghijklmnopqrstuvwxyzABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789";
    static int seeded = 0;
    if (!seeded) {
        srand((unsigned int)time(NULL) ^ (unsigned int)clock());
        seeded = 1;
    }
    for (size_t i = 0; i < len - 1; i++) {
        buffer[i] = charset[rand() % (sizeof(charset) - 1)];
    }
    buffer[len - 1] = '\0';
}

/* Free linked list of session data entries */
static void free_session_data(SessionDataEntry *data) {
    SessionDataEntry *current = data;
    while (current) {
        SessionDataEntry *next = current->next;
        /* Clear sensitive data before freeing */
        memset(current->value, 0, MAX_VALUE_LEN);
        free(current);
        current = next;
    }
}

/* Find a session slot using open addressing (linear probing) */
static Session *find_session_slot(SessionCache *cache, const char *session_id) {
    unsigned int index = hash_session_id(session_id);
    for (int i = 0; i < MAX_SESSIONS; i++) {
        unsigned int probe = (index + i) % MAX_SESSIONS;
        Session *s = &cache->sessions[probe];
        if (!s->slot_used) {
            return NULL;
        }
        if (strcmp(s->session_id, session_id) == 0) {
            return s;
        }
    }
    return NULL;
}

/* Check if a session has expired and handle expiration */
static void check_and_expire_session(Session *session) {
    if (session->status == SESSION_ACTIVE) {
        time_t now = time(NULL);
        if (now >= session->expires_at) {
            /* Free session data but keep the session ID cached */
            free_session_data(session->data);
            session->data = NULL;
            session->status = SESSION_EXPIRED;
            printf("[CACHE] Session '%s' expired. Data freed, ID cached for re-initialization.\n",
                   session->session_id);
        }
    }
}

/* Create a new session */
const char *session_create(SessionCache *cache, int ttl_seconds) {
    if (!cache) return NULL;

    if (ttl_seconds <= 0) {
        ttl_seconds = DEFAULT_TTL;
    }

    /* Generate a unique session ID */
    char new_id[SESSION_ID_LEN];
    int attempts = 0;
    do {
        generate_session_id(new_id, SESSION_ID_LEN);
        attempts++;
        if (attempts > 100) {
            fprintf(stderr, "Failed to generate unique session ID\n");
            return NULL;
        }
    } while (find_session_slot(cache, new_id) != NULL);

    /* Find an empty slot */
    unsigned int index = hash_session_id(new_id);
    Session *target = NULL;

    for (int i = 0; i < MAX_SESSIONS; i++) {
        unsigned int probe = (index + i) % MAX_SESSIONS;
        Session *s = &cache->sessions[probe];
        if (!s->slot_used) {
            target = s;
            break;
        }
    }

    if (!target) {
        /* Try to evict an expired/invalidated session */
        for (int i = 0; i < MAX_SESSIONS; i++) {
            Session *s = &cache->sessions[i];
            check_and_expire_session(s);
            if (s->slot_used && (s->status == SESSION_EXPIRED || s->status == SESSION_INVALIDATED)) {
                free_session_data(s->data);
                s->data = NULL;
                s->slot_used = false;
                target = s;
                cache->cached_id_count--;
                break;
            }
        }
    }

    if (!target) {
        fprintf(stderr, "Session cache is full\n");
        return NULL;
    }

    /* Initialize the session */
    strncpy(target->session_id, new_id, SESSION_ID_LEN - 1);
    target->session_id[SESSION_ID_LEN - 1] = '\0';
    target->data = NULL;
    target->created_at = time(NULL);
    target->last_accessed = target->created_at;
    target->expires_at = target->created_at + ttl_seconds;
    target->ttl = ttl_seconds;
    target->status = SESSION_ACTIVE;
    target->slot_used = true;
    cache->active_count++;

    printf("[CACHE] Session created: '%s' (TTL: %ds)\n", target->session_id, ttl_seconds);
    return target->session_id;
}

/* Re-initialize an expired session (reuse cached session ID) */
bool session_reinitialize(SessionCache *cache, const char *session_id, int ttl_seconds) {
    if (!cache || !session_id) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session) {
        fprintf(stderr, "Session ID '%s' not found in cache\n", session_id);
        return false;
    }

    if (session->status == SESSION_ACTIVE) {
        printf("[CACHE] Session '%s' is already active\n", session_id);
        return true;
    }

    if (session->status != SESSION_EXPIRED) {
        fprintf(stderr, "Session '%s' was invalidated and cannot be re-initialized\n", session_id);
        return false;
    }

    if (ttl_seconds <= 0) {
        ttl_seconds = DEFAULT_TTL;
    }

    /* Re-initialize with fresh timestamps */
    free_session_data(session->data);
    session->data = NULL;
    session->last_accessed = time(NULL);
    session->expires_at = session->last_accessed + ttl_seconds;
    session->ttl = ttl_seconds;
    session->status = SESSION_ACTIVE;
    cache->active_count++;
    cache->cached_id_count--;

    printf("[CACHE] Session re-initialized: '%s' (TTL: %ds)\n", session_id, ttl_seconds);
    return true;
}

/* Set a key-value pair in a session */
bool session_set(SessionCache *cache, const char *session_id, const char *key, const char *value) {
    if (!cache || !session_id || !key || !value) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session) {
        fprintf(stderr, "Session '%s' not found\n", session_id);
        return false;
    }

    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) {
        fprintf(stderr, "Session '%s' is not active (status: %d)\n", session_id, session->status);
        return false;
    }

    /* Update last accessed time and extend expiration */
    session->last_accessed = time(NULL);
    session->expires_at = session->last_accessed + session->ttl;

    /* Check if key already exists */
    SessionDataEntry *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            strncpy(current->value, value, MAX_VALUE_LEN - 1);
            current->value[MAX_VALUE_LEN - 1] = '\0';
            printf("[CACHE] Session '%s': updated key '%s'\n", session_id, key);
            return true;
        }
        current = current->next;
    }

    /* Create new entry */
    SessionDataEntry *entry = (SessionDataEntry *)malloc(sizeof(SessionDataEntry));
    if (!entry) {
        fprintf(stderr, "Failed to allocate session data entry\n");
        return false;
    }

    strncpy(entry->key, key, MAX_KEY_LEN - 1);
    entry->key[MAX_KEY_LEN - 1] = '\0';
    strncpy(entry->value, value, MAX_VALUE_LEN - 1);
    entry->value[MAX_VALUE_LEN - 1] = '\0';
    entry->next = session->data;
    session->data = entry;

    printf("[CACHE] Session '%s': set key '%s' = '%s'\n", session_id, key, value);
    return true;
}

/* Get a value from a session by key */
const char *session_get(SessionCache *cache, const char *session_id, const char *key) {
    if (!cache || !session_id || !key) return NULL;

    Session *session = find_session_slot(cache, session_id);
    if (!session) return NULL;

    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) {
        return NULL;
    }

    /* Update last accessed time and extend expiration */
    session->last_accessed = time(NULL);
    session->expires_at = session->last_accessed + session->ttl;

    SessionDataEntry *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            return current->value;
        }
        current = current->next;
    }

    return NULL;
}

/* Remove a specific key from a session */
bool session_remove_key(SessionCache *cache, const char *session_id, const char *key) {
    if (!cache || !session_id || !key) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session || session->status != SESSION_ACTIVE) return false;

    check_and_expire_session(session);
    if (session->status != SESSION_ACTIVE) return false;

    SessionDataEntry *prev = NULL;
    SessionDataEntry *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            if (prev) {
                prev->next = current->next;
            } else {
                session->data = current->next;
            }
            memset(current->value, 0, MAX_VALUE_LEN);
            free(current);
            printf("[CACHE] Session '%s': removed key '%s'\n", session_id, key);
            return true;
        }
        prev = current;
        current = current->next;
    }

    return false;
}

/* Invalidate a session - frees data but keeps ID cached */
bool session_invalidate(SessionCache *cache, const char *session_id, bool keep_cached) {
    if (!cache || !session_id) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session) return false;

    /* Free all session data */
    free_session_data(session->data);
    session->data = NULL;

    if (session->status == SESSION_ACTIVE) {
        cache->active_count--;
    }

    if (keep_cached) {
        /* Keep the session ID in cache for quick re-initialization */
        session->status = SESSION_EXPIRED;
        cache->cached_id_count++;
        printf("[CACHE] Session '%s' invalidated (ID cached for re-init)\n", session_id);
    } else {
        /* Completely remove the session */
        session->status = SESSION_INVALIDATED;
        session->slot_used = false;
        memset(session->session_id, 0, SESSION_ID_LEN);
        printf("[CACHE] Session '%s' fully removed from cache\n", session_id);
    }

    return true;
}

/* Expire all sessions that have passed their TTL */
int cache_cleanup_expired(SessionCache *cache) {
    if (!cache) return 0;

    int expired_count = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        Session *s = &cache->sessions[i];
        if (s->slot_used && s->status == SESSION_ACTIVE) {
            SessionStatus old_status = s->status;
            check_and_expire_session(s);
            if (s->status != old_status) {
                cache->active_count--;
                cache->cached_id_count++;
                expired_count++;
            }
        }
    }

    if (expired_count > 0) {
        printf("[CACHE] Cleanup: %d session(s) expired\n", expired_count);
    }
    return expired_count;
}

/* Get cache statistics */
void cache_stats(const SessionCache *cache) {
    if (!cache) return;

    int active = 0, expired = 0, invalidated = 0, empty = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        const Session *s = &cache->sessions[i];
        if (!s->slot_used) {
            empty++;
        } else {
            switch (s->status) {
                case SESSION_ACTIVE: active++; break;
                case SESSION_EXPIRED: expired++; break;
                case SESSION_INVALIDATED: invalidated++; break;
            }
        }
    }

    printf("\n=== Session Cache Statistics ===\n");
    printf("  Total slots:      %d\n", MAX_SESSIONS);
    printf("  Empty slots:      %d\n", empty);
    printf("  Active sessions:  %d\n", active);
    printf("  Expired (cached): %d\n", expired);
    printf("  Invalidated:      %d\n", invalidated);
    printf("================================\n\n");
}

/* Print all data in a session (for debugging) */
void session_dump(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return;

    Session *session = find_session_slot(cache, session_id);
    if (!session) {
        printf("Session '%s' not found\n", session_id);
        return;
    }

    const char *status_str;
    switch (session->status) {
        case SESSION_ACTIVE: status_str = "ACTIVE"; break;
        case SESSION_EXPIRED: status_str = "EXPIRED (cached)"; break;
        case SESSION_INVALIDATED: status_str = "INVALIDATED"; break;
        default: status_str = "UNKNOWN"; break;
    }

    printf("\n--- Session Dump: '%s' ---\n", session_id);
    printf("  Status:        %s\n", status_str);
    printf("  Created:       %s", ctime(&session->created_at));
    printf("  Last accessed: %s", ctime(&session->last_accessed));
    printf("  Expires:       %s", ctime(&session->expires_at));
    printf("  TTL:           %d seconds\n", session->ttl);

    if (session->data) {
        printf("  Data:\n");
        SessionDataEntry *entry = session->data;
        while (entry) {
            printf("    [%s] = '%s'\n", entry->key, entry->value);
            entry = entry->next;
        }
    } else {
        printf("  Data: (empty)\n");
    }
    printf("-----------------------------------\n\n");
}

/* Get list of all cached (expired) session IDs for potential re-initialization */
int cache_get_expired_ids(const SessionCache *cache, char ids[][SESSION_ID_LEN], int max_ids) {
    if (!cache || !ids || max_ids <= 0) return 0;

    int count = 0;
    for (int i = 0; i < MAX_SESSIONS && count < max_ids; i++) {
        const Session *s = &cache->sessions[i];
        if (s->slot_used && s->status == SESSION_EXPIRED) {
            strncpy(ids[count], s->session_id, SESSION_ID_LEN - 1);
            ids[count][SESSION_ID_LEN - 1] = '\0';
            count++;
        }
    }
    return count;
}

/* Check if a session exists (in any state) */
bool session_exists(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;
    return find_session_slot(cache, session_id) != NULL;
}

/* Check if a session is active */
bool session_is_active(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;
    Session *session = find_session_slot(cache, session_id);
    if (!session) return false;
    check_and_expire_session(session);
    return session->status == SESSION_ACTIVE;
}

/* Touch a session to reset its expiration timer */
bool session_touch(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session || session->status != SESSION_ACTIVE) return false;

    session->last_accessed = time(NULL);
    session->expires_at = session->last_accessed + session->ttl;
    return true;
}

/* Demo / Test */
int main(void) {
    printf("=== Session Cache System Demo ===\n\n");

    /* Create the cache */
    SessionCache *cache = cache_create();
    if (!cache) {
        fprintf(stderr, "Failed to create cache\n");
        return 1;
    }

    /* Create sessions */
    const char *sid1 = session_create(cache, 5);  /* 5 second TTL for demo */
    const char *sid2 = session_create(cache, 3600);
    const char *sid3 = session_create(cache, 3600);

    if (!sid1 || !sid2 || !sid3) {
        fprintf(stderr, "Failed to create sessions\n");
        cache_destroy(cache);
        return 1;
    }

    /* We need to copy session IDs since they point to internal storage */
    char session1[SESSION_ID_LEN], session2[SESSION_ID_LEN], session3[SESSION_ID_LEN];
    strncpy(session1, sid1, SESSION_ID_LEN);
    strncpy(session2, sid2, SESSION_ID_LEN);
    strncpy(session3, sid3, SESSION_ID_LEN);

    /* Set session data */
    session_set(cache, session1, "username", "alice");
    session_set(cache, session1, "role", "admin");
    session_set(cache, session1, "ip_address", "192.168.1.100");

    session_set(cache, session2, "username", "bob");
    session_set(cache, session2, "role", "user");
    session_set(cache, session2, "theme", "dark");

    session_set(cache, session3, "username", "charlie");
    session_set(cache, session3, "role", "moderator");

    /* Access session data */
    printf("\n--- Accessing Session Data ---\n");
    const char *val = session_get(cache, session1, "username");
    printf("Session 1 username: %s\n", val ? val : "(null)");

    val = session_get(cache, session2, "theme");
    printf("Session 2 theme: %s\n", val ? val : "(null)");

    val = session_get(cache, session1, "nonexistent");
    printf("Session 1 nonexistent key: %s\n", val ? val : "(null)");

    /* Update a value */
    session_set(cache, session2, "theme", "light");
    val = session_get(cache, session2, "theme");
    printf("Session 2 theme (updated): %s\n", val ? val : "(null)");

    /* Remove a key */
    session_remove_key(cache, session1, "ip_address");
    val = session_get(cache, session1, "ip_address");
    printf("Session 1 ip_address (after removal): %s\n", val ? val : "(null)");

    /* Dump sessions */
    session_dump(cache, session1);
    session_dump(cache, session2);

    /* Show cache stats */
    cache_stats(cache);

    /* Invalidate session 3 but keep ID cached */
    printf("--- Invalidating session 3 (keep cached) ---\n");
    session_invalidate(cache, session3, true);
    cache_stats(cache);

    /* Check session states */
    printf("Session 1 active: %s\n", session_is_active(cache, session1) ? "yes" : "no");
    printf("Session 3 exists: %s\n", session_exists(cache, session3) ? "yes" : "no");
    printf("Session 3 active: %s\n", session_is_active(cache, session3) ? "yes" : "no");

    /* Re-initialize session 3 */
    printf("\n--- Re-initializing session 3 ---\n");
    if (session_reinitialize(cache, session3, 7200)) {
        session_set(cache, session3, "username", "charlie_v2");
        session_set(cache, session3, "role", "admin");
        val = session_get(cache, session3, "username");
        printf("Session 3 username (re-initialized): %s\n", val ? val : "(null)");
    }

    cache_stats(cache);

    /* List expired session IDs */
    printf("--- Listing expired (cached) session IDs ---\n");
    char expired_ids[10][SESSION_ID_LEN];
    int num_expired = cache_get_expired_ids(cache, expired_ids, 10);
    printf("Expired cached IDs: %d\n", num_expired);
    for (int i = 0; i < num_expired; i++) {
        printf("  %s\n", expired_ids[i]);
    }

    /* Simulate waiting for session 1 to expire (5 second TTL) */
    printf("\n--- Waiting for session 1 to expire (5 seconds) ---\n");
    printf("Sleeping...\n");

    /* Instead of actually sleeping, we manually adjust the expiration for demo */
    Session *s1 = find_session_slot(cache, session1);
    if (s1) {
        s1->expires_at = time(NULL) - 1;  /* Force expiration */
    }

    /* Run cleanup */
    cache_cleanup_expired(cache);

    /* Try to access expired session */
    val = session_get(cache, session1, "username");
    printf("Session 1 username (after expiry): %s\n", val ? val : "(null)");
    printf("Session 1 exists (cached ID): %s\n", session_exists(cache, session1) ? "yes" : "no");
    printf("Session 1 active: %s\n", session_is_active(cache, session1) ? "yes" : "no");

    /* Re-initialize the expired session */
    printf("\n--- Re-initializing expired session 1 ---\n");
    if (session_reinitialize(cache, session1, 3600)) {
        session_set(cache, session1, "username", "alice_renewed");
        session_set(cache, session1, "role", "superadmin");
        val = session_get(cache, session1, "username");
        printf("Session 1 username (re-initialized): %s\n", val ? val : "(null)");
    }

    session_dump(cache, session1);
    cache_stats(cache);

    /* Fully remove session 2 */
    printf("--- Fully removing session 2 ---\n");
    session_invalidate(cache, session2, false);
    printf("Session 2 exists: %s\n", session_exists(cache, session2) ? "yes" : "no");

    cache_stats(cache);

    /* Clean up */
    cache_destroy(cache);
    printf("Cache destroyed. Done.\n");

    return 0;
}