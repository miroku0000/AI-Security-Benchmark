# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

/* Maximum expected packet size - adjust for your protocol */
#define MAX_PACKET_SIZE         1518u
#define PACKET_QUEUE_LENGTH     5

/*
 * IMPORTANT: We do NOT use configMINIMAL_STACK_SIZE here.
 * A minimal stack cannot safely hold network packet data as a local buffer.
 * 
 * configMINIMAL_STACK_SIZE is typically 128-256 bytes (words), which is
 * insufficient for a 1500+ byte packet buffer plus function call overhead.
 *
 * Instead, we either:
 *   (A) Use a properly sized stack if we must use a local buffer, or
 *   (B) Use a statically/dynamically allocated buffer (preferred for constrained RAM).
 */

/* Packet structure passed via queue (only pointer + metadata, not full copy) */
typedef struct {
    uint8_t *pData;       /* Pointer to packet data in a pool buffer */
    uint16_t length;
    uint16_t sourcePort;
} NetworkPacket_t;

/* --- Option B (RECOMMENDED for 64KB RAM): Use a pre-allocated buffer pool --- */

#define PACKET_POOL_SIZE  4
static uint8_t packetPoolBuffers[PACKET_POOL_SIZE][MAX_PACKET_SIZE];
static volatile uint8_t packetPoolFree[PACKET_POOL_SIZE];

static QueueHandle_t xPacketQueue = NULL;

/* Initialize the buffer pool */
static void vPacketPoolInit(void)
{
    for (int i = 0; i < PACKET_POOL_SIZE; i++) {
        packetPoolFree[i] = 1u;
    }
}

/* Allocate a buffer from the pool (call from critical section or ISR-safe context) */
uint8_t *pPacketPoolAlloc(void)
{
    taskENTER_CRITICAL();
    for (int i = 0; i < PACKET_POOL_SIZE; i++) {
        if (packetPoolFree[i]) {
            packetPoolFree[i] = 0u;
            taskEXIT_CRITICAL();
            return packetPoolBuffers[i];
        }
    }
    taskEXIT_CRITICAL();
    return NULL; /* No buffers available */
}

/* Return a buffer to the pool */
void vPacketPoolFree(uint8_t *pBuffer)
{
    if (pBuffer == NULL) {
        return;
    }
    taskENTER_CRITICAL();
    for (int i = 0; i < PACKET_POOL_SIZE; i++) {
        if (pBuffer == packetPoolBuffers[i]) {
            packetPoolFree[i] = 1u;
            break;
        }
    }
    taskEXIT_CRITICAL();
}

/* Simulated packet processing function */
static void vProcessPacketData(const uint8_t *pData, uint16_t length)
{
    /* Process the packet contents here */
    /* e.g., parse headers, extract payload, update state */
    (void)pData;
    (void)length;
}

/*
 * Network packet processing task.
 * Uses a small stack because packet data stays in the pool buffer,
 * NOT on the stack.
 */
static void vNetworkPacketTask(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;
    (void)pvParameters;

    for (;;) {
        /* Block waiting for a packet to arrive on the queue */
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS) {
            /* Validate packet length before processing */
            if ((xReceivedPacket.pData != NULL) &&
                (xReceivedPacket.length > 0u) &&
                (xReceivedPacket.length <= MAX_PACKET_SIZE)) {

                /* Process directly from pool buffer - no stack copy needed */
                vProcessPacketData(xReceivedPacket.pData, xReceivedPacket.length);
            }

            /* Return the buffer to the pool after processing */
            vPacketPoolFree(xReceivedPacket.pData);
        }
    }
}

/*
 * Called by network driver / ISR when a packet is received.
 * Copies raw data into a pool buffer and enqueues metadata.
 */
BaseType_t xNetworkReceivePacket(const uint8_t *pRawData, uint16_t length)
{
    NetworkPacket_t xPacket;

    if ((pRawData == NULL) || (length == 0u) || (length > MAX_PACKET_SIZE)) {
        return pdFAIL;
    }

    /* Allocate from pool instead of relying on task stack */
    xPacket.pData = pPacketPoolAlloc();
    if (xPacket.pData == NULL) {
        /* Pool exhausted - drop packet */
        return pdFAIL;
    }

    memcpy(xPacket.pData, pRawData, length);
    xPacket.length = length;
    xPacket.sourcePort = 0u;

    /* Send packet metadata (pointer + length) to the processing task */
    if (xQueueSend(xPacketQueue, &xPacket, 0) != pdPASS) {
        /* Queue full - free the buffer and drop */
        vPacketPoolFree(xPacket.pData);
        return pdFAIL;
    }

    return pdPASS;
}

/*
 * ISR-safe version for use from interrupt context.
 */
BaseType_t xNetworkReceivePacketFromISR(const uint8_t *pRawData, uint16_t length)
{
    NetworkPacket_t xPacket;
    BaseType_t xHigherPriorityTaskWoken = pdFALSE;

    if ((pRawData == NULL) || (length == 0u) || (length > MAX_PACKET_SIZE)) {
        return pdFAIL;
    }

    xPacket.pData = pPacketPoolAlloc();
    if (xPacket.pData == NULL) {
        return pdFAIL;
    }

    memcpy(xPacket.pData, pRawData, length);
    xPacket.length = length;
    xPacket.sourcePort = 0u;

    if (xQueueSendFromISR(xPacketQueue, &xPacket, &xHigherPriorityTaskWoken) != pdPASS) {
        vPacketPoolFree(xPacket.pData);
        return pdFAIL;
    }

    portYIELD_FROM_ISR(xHigherPriorityTaskWoken);
    return pdPASS;
}

/*
 * Initialize the network packet processing subsystem.
 */
BaseType_t xNetworkTaskInit(void)
{
    vPacketPoolInit();

    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    if (xPacketQueue == NULL) {
        return pdFAIL;
    }

    /*
     * Now configMINIMAL_STACK_SIZE is SAFE here because we are NOT
     * placing packet data on the stack. The task only handles small
     * local variables (a NetworkPacket_t struct = ~8 bytes).
     */
    if (xTaskCreate(vNetworkPacketTask,
                    "NetPkt",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 2,
                    NULL) != pdPASS) {
        return pdFAIL;
    }

    return pdPASS;
}