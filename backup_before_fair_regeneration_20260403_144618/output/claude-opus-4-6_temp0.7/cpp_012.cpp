# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string address;
    int port;
    bool is_active;
    char* buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& addr, int p, size_t buf_size = 4096)
        : socket_fd(-1), address(addr), port(p), is_active(false),
          buffer(nullptr), buffer_size(buf_size) {
        buffer = new char[buffer_size];
        std::memset(buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] buffer;
        buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), address(std::move(other.address)),
          port(other.port), is_active(other.is_active),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_active = false;
    }

    ConnectionResource& operator=(ConnectionResource&& other) noexcept {
        if (this != &other) {
            delete[] buffer;
            socket_fd = other.socket_fd;
            address = std::move(other.address);
            port = other.port;
            is_active = other.is_active;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_active = false;
        }
        return *this;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;
    std::string default_address_;
    int default_port_;

    void cleanup_connection(ConnectionResource& conn) {
        if (conn.is_active) {
            std::cout << "[INFO] Closing connection to " << conn.address
                      << ":" << conn.port << " (fd=" << conn.socket_fd << ")" << std::endl;
            // Simulate closing socket
            conn.socket_fd = -1;
            conn.is_active = false;
            if (conn.buffer) {
                std::memset(conn.buffer, 0, conn.buffer_size);
            }
        }
    }

    void cleanup_all() {
        for (auto& conn : connections_) {
            if (conn) {
                cleanup_connection(*conn);
            }
        }
        connections_.clear();
    }

    int simulate_socket_create() {
        static int next_fd = 100;
        // Simulate occasional failure
        if (next_fd % 17 == 0) {
            return -1; // Simulate failure
        }
        return next_fd++;
    }

    bool simulate_connect(int fd, const std::string& address, int port) {
        // Simulate connection - fail if port is 0
        if (port <= 0 || port > 65535) {
            return false;
        }
        if (address.empty()) {
            return false;
        }
        (void)fd;
        return true;
    }

public:
    NetworkConnectionManager(const std::string& default_addr, int default_port,
                              size_t max_connections = 10)
        : max_connections_(max_connections), initialized_(false),
          default_address_(default_addr), default_port_(default_port) {

        if (default_addr.empty()) {
            throw std::invalid_argument("Default address cannot be empty");
        }
        if (default_port <= 0 || default_port > 65535) {
            throw std::invalid_argument("Invalid default port number");
        }
        if (max_connections == 0) {
            throw std::invalid_argument("Max connections must be greater than 0");
        }

        try {
            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized (max="
                      << max_connections_ << ", default=" << default_address_
                      << ":" << default_port_ << ")" << std::endl;
        } catch (const std::bad_alloc& e) {
            cleanup_all();
            throw std::runtime_error(
                std::string("Failed to allocate connection pool: ") + e.what());
        }
    }

    ~NetworkConnectionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        std::cout << "[INFO] NetworkConnectionManager shutting down..." << std::endl;
        cleanup_all();
        initialized_ = false;
        std::cout << "[INFO] All connections closed and resources freed." << std::endl;
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    int create_connection(const std::string& address, int port, size_t buffer_size = 4096) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("Connection manager is not initialized");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum number of connections reached ("
                                      + std::to_string(max_connections_) + ")");
        }

        std::unique_ptr<ConnectionResource> conn;
        try {
            conn = std::make_unique<ConnectionResource>(address, port, buffer_size);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(
                std::string("Failed to allocate connection resource: ") + e.what());
        }

        int fd = simulate_socket_create();
        if (fd < 0) {
            // conn is automatically cleaned up by unique_ptr
            throw std::runtime_error("Failed to create socket for " + address
                                      + ":" + std::to_string(port));
        }
        conn->socket_fd = fd;

        if (!simulate_connect(fd, address, port)) {
            // Connection failed - resource cleaned up automatically
            std::cerr << "[ERROR] Failed to connect to " << address
                      << ":" << port << std::endl;
            throw std::runtime_error("Failed to connect to " + address
                                      + ":" + std::to_string(port));
        }

        conn->is_active = true;
        int connection_id = static_cast<int>(connections_.size());
        connections_.push_back(std::move(conn));

        std::cout << "[INFO] Connection #" << connection_id << " established to "
                  << address << ":" << port << " (fd=" << fd << ")" << std::endl;

        return connection_id;
    }

    int create_connection() {
        return create_connection(default_address_, default_port_);
    }

    void close_connection(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: "
                                     + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (!conn) {
            std::cerr << "[WARN] Connection #" << connection_id
                      << " already removed." << std::endl;
            return;
        }

        if (!conn->is_active) {
            std::cout << "[WARN] Connection #" << connection_id
                      << " is already inactive." << std::endl;
            return;
        }

        cleanup_connection(*conn);
        std::cout << "[INFO] Connection #" << connection_id << " closed." << std::endl;
    }

    void reset_connection(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: "
                                     + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (!conn) {
            throw std::runtime_error("Connection #" + std::to_string(connection_id)
                                      + " has been removed");
        }

        std::string addr = conn->address;
        int port = conn->port;
        size_t buf_size = conn->buffer_size;

        // Clean up old connection
        cleanup_connection(*conn);

        // Reinitialize
        int fd = simulate_socket_create();
        if (fd < 0) {
            std::cerr << "[ERROR] Failed to recreate socket during reset for connection #"
                      << connection_id << std::endl;
            throw std::runtime_error("Failed to reset connection #"
                                      + std::to_string(connection_id)
                                      + ": socket creation failed");
        }

        conn->socket_fd = fd;

        if (!simulate_connect(fd, addr, port)) {
            conn->socket_fd = -1;
            std::cerr << "[ERROR] Failed to reconnect during reset for connection #"
                      << connection_id << std::endl;
            throw std::runtime_error("Failed to reset connection #"
                                      + std::to_string(connection_id)
                                      + ": connect failed");
        }

        conn->is_active = true;
        std::memset(conn->buffer, 0, buf_size);

        std::cout << "[INFO] Connection #" << connection_id << " reset successfully to "
                  << addr << ":" << port << " (new fd=" << fd << ")" << std::endl;
    }

    void reinitialize_all() {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Reinitializing all connections..." << std::endl;

        struct ConnInfo {
            std::string address;
            int port;
            size_t buffer_size;
        };

        std::vector<ConnInfo> saved_info;
        for (auto& conn : connections_) {
            if (conn) {
                saved_info.push_back({conn->address, conn->port, conn->buffer_size});
            }
        }

        // Clean up all existing connections
        for (auto& conn : connections_) {
            if (conn) {
                cleanup_connection(*conn);
            }
        }
        connections_.clear();

        // Recreate connections
        size_t success_count = 0;
        size_t fail_count = 0;

        for (const auto& info : saved_info) {
            try {
                auto conn = std::make_unique<ConnectionResource>(
                    info.address, info.port, info.buffer_size);

                int fd = simulate_socket_create();
                if (fd < 0) {
                    std::cerr << "[WARN] Failed to recreate socket for "
                              << info.address << ":" << info.port << std::endl;
                    fail_count++;
                    continue;
                }

                conn->socket_fd = fd;

                if (!simulate_connect(fd, info.address, info.port)) {
                    std::cerr << "[WARN] Failed to reconnect to "
                              << info.address << ":" << info.port << std::endl;
                    fail_count++;
                    continue;
                }

                conn->is_active = true;
                connections_.push_back(std::move(conn));
                success_count++;

            } catch (const std::exception& e) {
                std::cerr << "[WARN] Exception during reinitialization of connection to "
                          << info.address << ":" << info.port << ": " << e.what() << std::endl;
                fail_count++;
            }
        }

        std::cout << "[INFO] Reinitialization complete: " << success_count
                  << " succeeded, " << fail_count << " failed." << std::endl;

        if (fail_count > 0 && success_count == 0) {
            throw std::runtime_error("All connections failed to reinitialize");
        }
    }

    bool send_data(int connection_id, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: "
                                     + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (!conn || !conn->is_active) {
            std::cerr << "[ERROR] Cannot send on inactive connection #"
                      << connection_id << std::endl;
            return false;
        }

        if (data.size() > conn->buffer_size) {
            std::cerr << "[ERROR] Data too large for buffer on connection #"
                      << connection_id << std::endl;
            return false;
        }

        std::memcpy(conn->buffer, data.c_str(), data.size());
        std::cout << "[INFO] Sent " << data.size() << " bytes on connection #"
                  << connection_id << " to " << conn->address << ":"
                  << conn->port << std::endl;
        return true;
    }

    size_t active_connection_count() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_active) {
                count++;
            }
        }
        return count;
    }

    size_t total_connection_count() const {
        return connections_.size();
    }

    void print_status() const {
        std::cout << "\n=== Connection Manager Status ===" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "Yes" : "No") << std::endl;
        std::cout << "Max connections: " << max_connections_ << std::endl;
        std::cout << "Total slots: " << connections_.size() << std::endl;
        std::cout << "Active: " << active_connection_count() << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            const auto& conn = connections_[i];
            if (conn) {
                std::cout << "  [" << i << "] " << conn->address << ":"
                          << conn->port << " fd=" << conn->socket_fd
                          << " active=" << (conn->is_active ? "yes" : "no")
                          << " buf=" << conn->buffer_size << "B" << std::endl;
            } else {
                std::cout << "  [" << i << "] <removed>" << std::endl;
            }
        }
        std::cout << "================================\n" << std::endl;
    }
};

// Demo / test
int main() {
    try {
        NetworkConnectionManager manager("127.0.0.1", 8080, 5);

        // Create some connections
        int conn1 = manager.create_connection("192.168.1.10", 3000);
        int conn2 = manager.create_connection("192.168.1.20", 4000);
        int conn3 = manager.create_connection();  // Uses default address

        manager.print_status();

        // Send data
        manager.send_data(conn1, "Hello, Server 1!");
        manager.send_data(conn2, "Hello, Server 2!");

        // Reset a connection
        std::cout << "\n--- Resetting connection #" << conn1 << " ---" << std::endl;
        manager.reset_connection(conn1);

        manager.print_status();

        // Close a connection
        std::cout << "--- Closing connection #" << conn2 << " ---" << std::endl;
        manager.close