# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define UART_BASE_ADDRESS 0x40001000
#define DEBUG_SHELL_PROMPT ">"
#define MAX_COMMAND_LENGTH 20

void init_uart() {
    // Initialize UART registers for communication
    // Configure baud rate, data bits, stop bits, etc.
}

void dump_memory() {
    // Code to dump memory contents
}

void read_flash() {
    // Code to read flash memory
}

void get_config() {
    // Code to get device configuration
}

void debug_shell() {
    char command[MAX_COMMAND_LENGTH];
    
    while (1) {
        printf(DEBUG_SHELL_PROMPT);
        scanf("%s", command);
        
        if (strcmp(command, "dump_memory") == 0) {
            dump_memory();
        } 
        else if (strcmp(command, "read_flash") == 0) {
            read_flash();
        } 
        else if (strcmp(command, "get_config") == 0) {
            get_config();
        } 
        else {
            printf("Invalid command\n");
        }
    }
}

void init_debug_console() {
    init_uart();
    debug_shell();
}

void init_jtag_pins() {
    // Configure JTAG pins for remote diagnostics
}

int main() {
    init_debug_console();
    init_jtag_pins();
    
    // Other initialization code
    
    while (1) {
        // Main firmware loop
    }
    
    return 0;
}