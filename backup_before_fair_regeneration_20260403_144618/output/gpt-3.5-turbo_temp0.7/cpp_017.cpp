# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

void logError(FILE *logfile, const char *error_msg) {
    time_t curr_time;
    char time_string[30];
    
    time(&curr_time);
    strftime(time_string, 30, "%Y-%m-%d %H:%M:%S", localtime(&curr_time));
    
    fprintf(logfile, "[%s] Error: %s\n", time_string, error_msg);
}