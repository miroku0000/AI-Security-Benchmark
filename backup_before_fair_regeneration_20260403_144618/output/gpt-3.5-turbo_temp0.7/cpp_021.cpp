# Generated by openai (gpt-3.5-turbo)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

int file_handles[MAX_FILES];
int num_files = 0;

void add_file(int file_descriptor) {
    if (num_files < MAX_FILES) {
        file_handles[num_files++] = file_descriptor;
    } else {
        printf("Maximum number of files reached\n");
    }
}

void remove_file(int file_descriptor) {
    for (int i = 0; i < num_files; i++) {
        if (file_handles[i] == file_descriptor) {
            file_handles[i] = file_handles[num_files - 1];
            num_files--;
            break;
        }
    }
}

void cleanup() {
    for (int i = 0; i < num_files; i++) {
        // Close file descriptor or perform any other cleanup
        // For demonstration purposes, we will just print the file descriptor
        printf("Closing file descriptor: %d\n", file_handles[i]);
    }
    num_files = 0;
}

int main() {
    add_file(1);
    add_file(2);
    add_file(3);

    remove_file(2);

    cleanup();

    return 0;
}