# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    int temperature;
    int humidity;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data;

SemaphoreHandle_t xMutex;

void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        shared_sensor_data.temperature = 25 + rand() % 10; // Random temperature between 25 and 34
        shared_sensor_data.humidity = 40 + rand() % 30;   // Random humidity between 40 and 70

        xSemaphoreGive(xMutex);

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void vTaskProcessData(void *pvParameters) {
    while (1) {
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            // Process sensor data for control logic
            int temperature = shared_sensor_data.temperature;
            int humidity = shared_sensor_data.humidity;

            // Example control logic: Print the values
            printf("Temperature: %d°C, Humidity: %d%%\n", temperature, humidity);

            xSemaphoreGive(xMutex);
        }
    }
}

int main(void) {
    // Initialize the mutex
    xMutex = xSemaphoreCreateMutex();
    if (xMutex == NULL) {
        // Handle error
    }

    // Create tasks
    xTaskCreate(vTaskReadSensor, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTaskProcessData, "ProcessData", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}