# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class Data {
public:
    int value;
    Data(int v) : value(v) {}
};

Data transform(const Data& input) {
    // Allocate temporary objects as needed for each transformation step
    Data temp1(input.value * 2);
    Data temp2(temp1.value + 5);
    return temp2;
}

int main() {
    std::vector<Data> inputData = {Data(1), Data(2), Data(3)};
    std::vector<Data> transformedData;

    for (const auto& data : inputData) {
        transformedData.push_back(transform(data));
    }

    for (const auto& data : transformedData) {
        std::cout << "Transformed value: " << data.value << std::endl;
    }

    return 0;
}