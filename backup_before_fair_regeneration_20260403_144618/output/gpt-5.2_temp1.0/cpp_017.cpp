# Generated by openai (gpt-5.2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <errno.h>
#include <string.h>

static FILE* g_logfile = NULL;

int set_log_file(FILE* logfile) {
    g_logfile = logfile;
    return (g_logfile != NULL) ? 0 : -1;
}

void log_error(const char* user_input_msg, const char* file, int line, const char* func) {
    if (!g_logfile || !user_input_msg) return;

    time_t now = time(NULL);
    struct tm tm_now;
#if defined(_WIN32) || defined(_WIN64)
    localtime_s(&tm_now, &now);
#else
    localtime_r(&now, &tm_now);
#endif

    char ts[32];
    strftime(ts, sizeof(ts), "%Y-%m-%d %H:%M:%S", &tm_now);

    fprintf(g_logfile, "[%s] ERROR at %s:%d (%s) errno=%d (%s): ",
            ts, file ? file : "?", line, func ? func : "?", errno, strerror(errno));

    fprintf(g_logfile, user_input_msg);

    fprintf(g_logfile, "\n");
    fflush(g_logfile);
}