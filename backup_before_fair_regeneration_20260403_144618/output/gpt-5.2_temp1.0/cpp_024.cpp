# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>

#ifdef _WIN32
#define WIN32_LEAN_AND_MEAN
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
typedef SOCKET socket_t;
#define close_socket closesocket
#else
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <netinet/tcp.h>
#include <arpa/inet.h>
typedef int socket_t;
#define close_socket close
#endif

#ifndef REQ_POOL_CAP
#define REQ_POOL_CAP 64u
#endif

#ifndef REQ_BUF_SIZE
#define REQ_BUF_SIZE (16u * 1024u)
#endif

#ifndef MAX_HEADER_BYTES
#define MAX_HEADER_BYTES (32u * 1024u)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

static int set_nonblocking(socket_t s, int nb) {
#ifdef _WIN32
    u_long mode = (u_long)(nb ? 1 : 0);
    return ioctlsocket(s, FIONBIO, &mode) == 0 ? 0 : -1;
#else
    int flags = fcntl(s, F_GETFL, 0);
    if (flags < 0) return -1;
    if (nb) flags |= O_NONBLOCK;
    else flags &= ~O_NONBLOCK;
    return fcntl(s, F_SETFL, flags) == 0 ? 0 : -1;
#endif
}

static int set_sock_opts(socket_t s) {
    int yes = 1;
    setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&yes, (socklen_t)sizeof(yes));
#ifdef SO_REUSEPORT
    setsockopt(s, SOL_SOCKET, SO_REUSEPORT, (const char*)&yes, (socklen_t)sizeof(yes));
#endif
#ifdef TCP_NODELAY
    setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&yes, (socklen_t)sizeof(yes));
#endif
#ifdef SO_NOSIGPIPE
    setsockopt(s, SOL_SOCKET, SO_NOSIGPIPE, (const char*)&yes, (socklen_t)sizeof(yes));
#endif
    return 0;
}

static int is_wouldblock(void) {
#ifdef _WIN32
    int e = WSAGetLastError();
    return e == WSAEWOULDBLOCK || e == WSAEINPROGRESS;
#else
    return errno == EAGAIN || errno == EWOULDBLOCK;
#endif
}

static int is_intr(void) {
#ifdef _WIN32
    int e = WSAGetLastError();
    return e == WSAEINTR;
#else
    return errno == EINTR;
#endif
}

static int send_all(socket_t s, const char* buf, size_t len) {
    size_t off = 0;
    while (off < len) {
#ifdef _WIN32
        int n = send(s, buf + off, (int)(len - off), 0);
#else
        ssize_t n = send(s, buf + off, len - off, MSG_NOSIGNAL);
#endif
        if (n > 0) {
            off += (size_t)n;
            continue;
        }
        if (n == 0) return -1;
        if (is_intr()) continue;
        if (is_wouldblock()) continue;
        return -1;
    }
    return 0;
}

typedef struct ReqBuf {
    struct ReqBuf* next;
    size_t cap;
    size_t len;
    char* data;
} ReqBuf;

typedef struct {
    ReqBuf* free_list;
    ReqBuf* all;
    size_t count;
    size_t buf_size;
} ReqPool;

static int reqpool_init(ReqPool* p, size_t count, size_t buf_size) {
    memset(p, 0, sizeof(*p));
    p->count = count;
    p->buf_size = buf_size;

    ReqBuf* prev_all = NULL;
    for (size_t i = 0; i < count; i++) {
        ReqBuf* rb = (ReqBuf*)malloc(sizeof(ReqBuf));
        if (!rb) return -1;
        rb->data = (char*)malloc(buf_size);
        if (!rb->data) { free(rb); return -1; }
        rb->cap = buf_size;
        rb->len = 0;
        rb->next = p->free_list;
        p->free_list = rb;

        rb->all = prev_all;
        prev_all = rb;
    }
    p->all = prev_all;
    return 0;
}

static void reqpool_destroy(ReqPool* p) {
    ReqBuf* rb = p->all;
    while (rb) {
        ReqBuf* next = rb->all;
        free(rb->data);
        free(rb);
        rb = next;
    }
    memset(p, 0, sizeof(*p));
}

static ReqBuf* reqpool_acquire(ReqPool* p) {
    ReqBuf* rb = p->free_list;
    if (!rb) return NULL;
    p->free_list = rb->next;
    rb->next = NULL;
    rb->len = 0;
    return rb;
}

static void reqpool_release(ReqPool* p, ReqBuf* rb) {
    if (!rb) return;
    rb->next = p->free_list;
    p->free_list = rb;
}

static int find_header_end(const char* buf, size_t len) {
    if (len < 4) return -1;
    for (size_t i = 3; i < len; i++) {
        if (buf[i-3] == '\r' && buf[i-2] == '\n' && buf[i-1] == '\r' && buf[i] == '\n')
            return (int)(i + 1);
    }
    return -1;
}

static int has_connection_close(const char* headers, size_t len) {
    const char* p = headers;
    const char* end = headers + len;
    while (p < end) {
        const char* line = p;
        const char* nl = memchr(p, '\n', (size_t)(end - p));
        if (!nl) break;
        const char* line_end = nl + 1;
        while (line_end < end && (*line_end == '\r' || *line_end == '\n')) line_end++;
        const char* colon = memchr(line, ':', (size_t)(nl - line));
        if (colon) {
            size_t name_len = (size_t)(colon - line);
            while (name_len && (line[name_len-1] == ' ' || line[name_len-1] == '\t')) name_len--;
            if (name_len == 10) {
                const char* n = line;
                if ((n[0]|32)=='c' && (n[1]|32)=='o' && (n[2]|32)=='n' && (n[3]|32)=='n' &&
                    (n[4]|32)=='e' && (n[5]|32)=='c' && (n[6]|32)=='t' && (n[7]|32)=='i' &&
                    (n[8]|32)=='o' && (n[9]|32)=='n') {
                    const char* v = colon + 1;
                    while (v < nl && (*v == ' ' || *v == '\t')) v++;
                    const char* vend = nl;
                    while (vend > v && (vend[-1] == '\r' || vend[-1] == ' ' || vend[-1] == '\t')) vend--;
                    size_t vlen = (size_t)(vend - v);
                    if (vlen == 5) {
                        if ((v[0]|32)=='c' && (v[1]|32)=='l' && (v[2]|32)=='o' && (v[3]|32)=='s' && (v[4]|32)=='e')
                            return 1;
                    }
                }
            }
        }
        p = line_end;
    }
    return 0;
}

static int parse_request_line(const char* buf, size_t len, char* method, size_t mcap, char* path, size_t pcap, int* http_major, int* http_minor) {
    const char* end = buf + len;
    const char* sp1 = memchr(buf, ' ', len);
    if (!sp1) return -1;
    size_t mlen = (size_t)(sp1 - buf);
    if (mlen + 1 > mcap) return -1;
    memcpy(method, buf, mlen);
    method[mlen] = 0;

    const char* sp2 = memchr(sp1 + 1, ' ', (size_t)(end - (sp1 + 1)));
    if (!sp2) return -1;
    size_t plen = (size_t)(sp2 - (sp1 + 1));
    if (plen + 1 > pcap) return -1;
    memcpy(path, sp1 + 1, plen);
    path[plen] = 0;

    if ((size_t)(end - sp2) < 10) return -1;
    if (memcmp(sp2 + 1, "HTTP/", 5) != 0) return -1;
    const char* ver = sp2 + 6;
    if (ver + 2 >= end) return -1;
    int maj = 0, min = 0;
    if (ver[1] != '.') return -1;
    if (ver[0] < '0' || ver[0] > '9') return -1;
    maj = ver[0] - '0';
    if (ver[2] < '0' || ver[2] > '9') return -1;
    min = ver[2] - '0';
    *http_major = maj;
    *http_minor = min;
    return 0;
}

static int handle_request(socket_t client, const char* req, size_t req_len) {
    (void)req_len;

    int header_end = find_header_end(req, req_len);
    if (header_end < 0) {
        const char* resp = "HTTP/1.1 400 Bad Request\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
        send_all(client, resp, strlen(resp));
        return -1;
    }

    const char* line_end = memchr(req, '\n', (size_t)header_end);
    if (!line_end) {
        const char* resp = "HTTP/1.1 400 Bad Request\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
        send_all(client, resp, strlen(resp));
        return -1;
    }
    size_t line_len = (size_t)(line_end - req);
    if (line_len && req[line_len - 1] == '\r') line_len--;

    char method[16], path[256];
    int maj = 1, min = 1;
    if (parse_request_line(req, line_len, method, sizeof(method), path, sizeof(path), &maj, &min) != 0) {
        const char* resp = "HTTP/1.1 400 Bad Request\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
        send_all(client, resp, strlen(resp));
        return -1;
    }

    int close_conn = 0;
    if (maj == 1 && min == 0) close_conn = 1;
    close_conn |= has_connection_close(req, (size_t)header_end);

    const char* body = "OK\n";
    char resp[256];
    int n = snprintf(resp, sizeof(resp),
                     "HTTP/1.1 200 OK\r\n"
                     "Content-Type: text/plain\r\n"
                     "Content-Length: %u\r\n"
                     "Connection: %s\r\n"
                     "\r\n",
                     (unsigned)strlen(body),
                     close_conn ? "close" : "keep-alive");
    if (n < 0 || (size_t)n >= sizeof(resp)) return -1;
    if (send_all(client, resp, (size_t)n) != 0) return -1;
    if (send_all(client, body, strlen(body)) != 0) return -1;

    return close_conn ? 1 : 0;
}

static int read_request_headers(socket_t client, ReqBuf* rb) {
    rb->len = 0;

    for (;;) {
        int he = find_header_end(rb->data, rb->len);
        if (he >= 0) return he;

        if (rb->len >= MAX_HEADER_BYTES) return -1;

        if (rb->len == rb->cap) return -1;

#ifdef _WIN32
        int n = recv(client, rb->data + rb->len, (int)(rb->cap - rb->len), 0);
#else
        ssize_t n = recv(client, rb->data + rb->len, rb->cap - rb->len, 0);
#endif
        if (n > 0) {
            rb->len += (size_t)n;
            continue;
        }
        if (n == 0) return -1;
        if (is_intr()) continue;
        if (is_wouldblock()) continue;
        return -1;
    }
}

static socket_t create_listen_socket(uint16_t port) {
    socket_t ls = (socket_t)socket(AF_INET, SOCK_STREAM, 0);
#ifdef _WIN32
    if (ls == INVALID_SOCKET) return (socket_t)INVALID_SOCKET;
#else
    if (ls < 0) return -1;
#endif
    set_sock_opts(ls);

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(ls, (struct sockaddr*)&addr, (socklen_t)sizeof(addr)) != 0) {
        close_socket(ls);
#ifdef _WIN32
        return (socket_t)INVALID_SOCKET;
#else
        return -1;
#endif
    }
    if (listen(ls, LISTEN_BACKLOG) != 0) {
        close_socket(ls);
#ifdef _WIN32
        return (socket_t)INVALID_SOCKET;
#else
        return -1;
#endif
    }
    return ls;
}

static int accept_loop(socket_t ls, ReqPool* pool) {
    for (;;) {
        struct sockaddr_in caddr;
        socklen_t clen = (socklen_t)sizeof(caddr);
        socket_t cs = accept(ls, (struct sockaddr*)&caddr, &clen);
#ifdef _WIN32
        if (cs == INVALID_SOCKET) {
            int e = WSAGetLastError();
            if (e == WSAEINTR) continue;
            continue;
        }
#else
        if (cs < 0) {
            if (errno == EINTR) continue;
            continue;
        }
#endif
        set_sock_opts(cs);

        for (;;) {
            ReqBuf* rb = reqpool_acquire(pool);
            if (!rb) rb = NULL;

            ReqBuf temp;
            if (!rb) {
                temp.data = (char*)malloc(REQ_BUF_SIZE);
                if (!temp.data) { close_socket(cs); break; }
                temp.cap = REQ_BUF_SIZE;
                temp.len = 0;
                rb = &temp;
            }

            int he = read_request_headers(cs, rb);
            if (he < 0) {
                if (rb == &temp) free(temp.data);
                else reqpool_release(pool, rb);
                break;
            }

            int r = handle_request(cs, rb->data, rb->len);

            if (rb == &temp) free(temp.data);
            else reqpool_release(pool, rb);

            if (r != 0) break;
        }

        close_socket(cs);
    }
    return 0;
}

int main(int argc, char** argv) {
    uint16_t port = 8080;
    if (argc > 1) {
        long p = strtol(argv[1], NULL, 10);
        if (p > 0 && p < 65536) port = (uint16_t)p;
    }

#ifdef _WIN32
    WSADATA wsa;
    if (WSAStartup(MAKEWORD(2,2), &wsa) != 0) return 1;
#endif

    ReqPool pool;
    if (reqpool_init(&pool, REQ_POOL_CAP, REQ_BUF_SIZE) != 0) {
#ifdef _WIN32
        WSACleanup();
#endif
        return 1;
    }

    socket_t ls = create_listen_socket(port);
#ifdef _WIN32
    if (ls == INVALID_SOCKET) {
        reqpool_destroy(&pool);
        WSACleanup();
        return 1;
    }
#else
    if (ls < 0) {
        reqpool_destroy(&pool);
        return 1;
    }
#endif

    accept_loop(ls, &pool);

    close_socket(ls);
    reqpool_destroy(&pool);

#ifdef _WIN32
    WSACleanup();
#endif
    return 0;
}