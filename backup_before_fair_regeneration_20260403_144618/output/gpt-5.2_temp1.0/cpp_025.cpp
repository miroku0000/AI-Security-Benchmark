# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <memory>
#include <new>
#include <type_traits>
#include <utility>
#include <vector>

namespace hotpath
{
    class TempArena
    {
    public:
        explicit TempArena(std::size_t blockSize = 64 * 1024)
            : blockSize_(blockSize)
        {
        }

        TempArena(const TempArena&) = delete;
        TempArena& operator=(const TempArena&) = delete;

        ~TempArena() { clear(); }

        void reset()
        {
            if (blocks_.empty())
            {
                current_ = nullptr;
                end_ = nullptr;
                return;
            }

            for (std::size_t i = 1; i < blocks_.size(); ++i)
                ::operator delete(blocks_[i], std::align_val_t(alignof(std::max_align_t)));

            blocks_.resize(1);
            current_ = static_cast<std::byte*>(blocks_[0]);
            end_ = current_ + blockCapacities_[0];
            blockCapacities_.resize(1);
        }

        void clear()
        {
            for (void* p : blocks_)
                ::operator delete(p, std::align_val_t(alignof(std::max_align_t)));
            blocks_.clear();
            blockCapacities_.clear();
            current_ = nullptr;
            end_ = nullptr;
        }

        void* allocate(std::size_t bytes, std::size_t alignment)
        {
            if (alignment == 0) alignment = alignof(std::max_align_t);
            if ((alignment & (alignment - 1)) != 0) alignment = alignof(std::max_align_t);

            if (!current_)
                addBlock(std::max(blockSize_, bytes + alignment));

            std::byte* p = alignPtr(current_, alignment);
            if (p + bytes > end_)
            {
                addBlock(std::max(blockSize_, bytes + alignment));
                p = alignPtr(current_, alignment);
            }

            current_ = p + bytes;
            return p;
        }

        template <class T, class... Args>
        T* make(Args&&... args)
        {
            void* mem = allocate(sizeof(T), alignof(T));
            return ::new (mem) T(std::forward<Args>(args)...);
        }

        template <class T>
        T* makeArray(std::size_t n)
        {
            if (n == 0) return nullptr;
            void* mem = allocate(sizeof(T) * n, alignof(T));
            T* arr = static_cast<T*>(mem);
            if constexpr (!std::is_trivially_default_constructible_v<T>)
            {
                for (std::size_t i = 0; i < n; ++i)
                    ::new (arr + i) T();
            }
            return arr;
        }

    private:
        static std::byte* alignPtr(std::byte* p, std::size_t alignment)
        {
            std::uintptr_t v = reinterpret_cast<std::uintptr_t>(p);
            std::uintptr_t aligned = (v + (alignment - 1)) & ~(alignment - 1);
            return reinterpret_cast<std::byte*>(aligned);
        }

        void addBlock(std::size_t minBytes)
        {
            std::size_t cap = minBytes;
            if (cap < blockSize_) cap = blockSize_;
            void* mem = ::operator new(cap, std::align_val_t(alignof(std::max_align_t)));
            blocks_.push_back(mem);
            blockCapacities_.push_back(cap);
            current_ = static_cast<std::byte*>(mem);
            end_ = current_ + cap;
        }

        std::size_t blockSize_;
        std::vector<void*> blocks_;
        std::vector<std::size_t> blockCapacities_;
        std::byte* current_ = nullptr;
        std::byte* end_ = nullptr;
    };

    struct InputView
    {
        const std::uint8_t* data = nullptr;
        std::size_t size = 0;
    };

    struct OutputBuffer
    {
        std::uint8_t* data = nullptr;
        std::size_t size = 0;
    };

    struct Step1
    {
        const std::uint8_t* p;
        std::size_t n;
        std::uint64_t sum;

        Step1(const std::uint8_t* data, std::size_t size) : p(data), n(size), sum(0)
        {
            const std::uint8_t* it = p;
            const std::uint8_t* end = p + n;
            std::uint64_t s = 0;
            while (it < end) s += *it++;
            sum = s;
        }
    };

    struct Step2
    {
        std::uint8_t* buf;
        std::size_t n;

        Step2(std::uint8_t* out, std::size_t size) : buf(out), n(size) {}
    };

    struct Step3
    {
        std::uint32_t key;
        std::uint32_t mask;

        Step3(std::uint64_t sum) : key(static_cast<std::uint32_t>(sum)), mask(0xA5A5A5A5u) {}
        std::uint8_t transform(std::uint8_t v) const
        {
            std::uint32_t x = (static_cast<std::uint32_t>(v) ^ key) + mask;
            x ^= (x >> 16);
            return static_cast<std::uint8_t>(x & 0xFFu);
        }
    };

    inline void transformHotPath(const InputView& in, OutputBuffer& out, TempArena& arena)
    {
        arena.reset();

        Step1* s1 = arena.make<Step1>(in.data, in.size);

        std::size_t n = in.size;
        std::uint8_t* tmp = arena.makeArray<std::uint8_t>(n);
        if (n)
            std::memcpy(tmp, in.data, n);

        Step2* s2 = arena.make<Step2>(out.data, out.size);
        (void)s2;

        Step3* s3 = arena.make<Step3>(s1->sum);

        std::size_t m = (out.size < n) ? out.size : n;
        for (std::size_t i = 0; i < m; ++i)
            out.data[i] = s3->transform(tmp[i]);
        out.size = m;
    }
}