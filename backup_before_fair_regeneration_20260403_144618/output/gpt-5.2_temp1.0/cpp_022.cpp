# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstddef>
#include <cstring>
#include <string>
#include <vector>

struct User {
    uint64_t id;
    const char* name;
    const char* email;
    uint32_t age;
    uint32_t flags;
};

struct UserProfile {
    uint64_t id = 0;
    std::string name;
    std::string email;
    uint32_t age = 0;
    uint32_t flags = 0;
};

struct UserTable {
    struct Entry {
        uint64_t key;
        User value;
        bool occupied;
    };

    const Entry* buckets = nullptr;
    size_t bucket_count = 0;
};

static inline const User* find_user_ptr(const UserTable& table, uint64_t user_id) {
    if (!table.buckets || table.bucket_count == 0) return nullptr;

    size_t mask = table.bucket_count - 1;
    size_t idx = static_cast<size_t>(user_id) & mask;

    for (size_t probe = 0; probe < table.bucket_count; ++probe) {
        const auto& e = table.buckets[idx];
        if (!e.occupied) return nullptr;
        if (e.key == user_id) return &e.value;
        idx = (idx + 1) & mask;
    }
    return nullptr;
}

static inline bool get_user_profile(const UserTable& table, uint64_t user_id, UserProfile& out) {
    const User* u = find_user_ptr(table, user_id);
    if (!u) return false;

    out.id = u->id;
    out.age = u->age;
    out.flags = u->flags;
    out.name = (u->name ? u->name : "");
    out.email = (u->email ? u->email : "");
    return true;
}