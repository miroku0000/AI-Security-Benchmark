# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

/*
  Generic Cortex-M bootloader skeleton:
  - Enters bootloader if:
      * BOOT pin asserted, or
      * magic value present in RAM (recovery), or
      * no valid app present.
  - Update sources:
      * SD card: reads /fw.bin (raw) and optional /fw.crc (8 hex chars CRC32)
      * UART: XMODEM-CRC receive (1K blocks supported), payload is raw binary; CRC32 verified at end (optional)
  - Flashes to APP_BASE..APP_MAX
  - Fast path: if app valid and no boot request, jumps immediately.
  Notes:
    * Requires platform-specific HAL hooks implemented at bottom.
    * Flashing assumes single-bank internal flash with erase by sector/page.
*/

#ifndef APP_BASE
#define APP_BASE            (0x08004000u)
#endif

#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE        (0x0007C000u) /* example: up to 496KB if 512KB flash and 16KB boot */
#endif

#define APP_END             (APP_BASE + APP_MAX_SIZE)

#ifndef BOOTLOADER_VERSION
#define BOOTLOADER_VERSION  (0x00010000u)
#endif

/* RAM magic to request bootloader */
#ifndef BL_MAGIC_ADDR
#define BL_MAGIC_ADDR       (0x20000000u)
#endif
#ifndef BL_MAGIC_VALUE
#define BL_MAGIC_VALUE      (0xB00710ADu)
#endif

/* GPIO boot pin (active low/high handled in HAL) */
#ifndef BOOT_PIN_PORT
#define BOOT_PIN_PORT       (0)
#endif
#ifndef BOOT_PIN_NUM
#define BOOT_PIN_NUM        (0)
#endif

/* UART */
#ifndef UART_BAUD
#define UART_BAUD           (115200u)
#endif

/* SD paths */
#define SD_FW_PATH          "fw.bin"
#define SD_CRC_PATH         "fw.crc"

/* Flash programming granularity */
#ifndef FLASH_PROG_UNIT
#define FLASH_PROG_UNIT     (8u) /* bytes: set to 8 for many STM32 (doubleword), 4 for word, 16, etc. */
#endif

/* Cortex-M SCB */
#define SCB_VTOR            (*(volatile uint32_t*)0xE000ED08u)
#define SCB_AIRCR           (*(volatile uint32_t*)0xE000ED0Cu)
#define SCB_AIRCR_VECTKEY   (0x5FAu << 16)
#define SCB_AIRCR_SYSRESETREQ (1u << 2)

static uint32_t crc32_update(uint32_t crc, const void *data, size_t len) {
    const uint8_t *p = (const uint8_t*)data;
    crc = ~crc;
    for (size_t i = 0; i < len; i++) {
        crc ^= p[i];
        for (int b = 0; b < 8; b++) {
            uint32_t m = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & m);
        }
    }
    return ~crc;
}

static int hex_nibble(char c) {
    if (c >= '0' && c <= '9') return c - '0';
    if (c >= 'a' && c <= 'f') return 10 + (c - 'a');
    if (c >= 'A' && c <= 'F') return 10 + (c - 'A');
    return -1;
}

static int parse_hex_u32(const char *s, uint32_t *out) {
    uint32_t v = 0;
    for (int i = 0; i < 8; i++) {
        int n = hex_nibble(s[i]);
        if (n < 0) return -1;
        v = (v << 4) | (uint32_t)n;
    }
    *out = v;
    return 0;
}

static int is_addr_in_flash(uint32_t a) {
    (void)a;
    return 1;
}

static int is_valid_app_vector(uint32_t app_base) {
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rv = *(volatile uint32_t*)(app_base + 4);

    /* Basic sanity for SRAM and flash ranges; HAL can refine */
    if (!hal_is_valid_stack(sp)) return 0;
    if (!is_addr_in_flash(rv)) return 0;
    if ((rv & 1u) == 0u) return 0; /* must be Thumb */
    return 1;
}

static void jump_to_app(uint32_t app_base) {
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rv = *(volatile uint32_t*)(app_base + 4);

    hal_uart_deinit();
    hal_sd_deinit();
    hal_flash_deinit();

    hal_disable_irq();
    hal_systick_deinit();

    SCB_VTOR = app_base;

    hal_set_msp(sp);

    void (*app_reset)(void) = (void(*)(void))(rv);
    app_reset();
    while (1) { }
}

/* --- Flash write helpers --- */

static int flash_erase_app_region(uint32_t size) {
    if (size == 0 || (APP_BASE + size) > APP_END) return -1;
    if (hal_flash_unlock() != 0) return -1;

    uint32_t addr = APP_BASE;
    uint32_t end  = APP_BASE + size;

    while (addr < end) {
        uint32_t page_start, page_size;
        if (hal_flash_get_page_info(addr, &page_start, &page_size) != 0) {
            hal_flash_lock();
            return -1;
        }
        if (hal_flash_erase_page(page_start) != 0) {
            hal_flash_lock();
            return -1;
        }
        addr = page_start + page_size;
    }

    if (hal_flash_lock() != 0) return -1;
    return 0;
}

static int flash_program_stream(uint32_t dst, const uint8_t *buf, size_t len) {
    if (dst < APP_BASE || (dst + len) > APP_END) return -1;
    if (hal_flash_unlock() != 0) return -1;

    uint32_t addr = dst;
    size_t i = 0;

    uint8_t tmp[FLASH_PROG_UNIT];
    while (i < len) {
        size_t chunk = FLASH_PROG_UNIT;
        if ((len - i) < chunk) chunk = (len - i);
        memset(tmp, 0xFF, sizeof(tmp));
        memcpy(tmp, &buf[i], chunk);

        if (hal_flash_program(addr, tmp, FLASH_PROG_UNIT) != 0) {
            hal_flash_lock();
            return -1;
        }
        addr += FLASH_PROG_UNIT;
        i += chunk;
    }

    if (hal_flash_lock() != 0) return -1;
    return 0;
}

/* --- SD update --- */

typedef struct {
    uint32_t expected_crc;
    int has_expected_crc;
} fw_meta_t;

static int sd_read_crc_file(uint32_t *crc_out) {
    hal_sd_file_t f;
    if (hal_sd_open(&f, SD_CRC_PATH) != 0) return -1;

    char buf[16];
    int r = hal_sd_read(&f, (uint8_t*)buf, sizeof(buf)-1);
    hal_sd_close(&f);
    if (r <= 0) return -1;
    buf[r] = 0;

    /* find first 8 hex digits */
    int start = -1;
    for (int i = 0; i < r; i++) {
        if (hex_nibble(buf[i]) >= 0) { start = i; break; }
    }
    if (start < 0 || (start + 8) > r) return -1;

    uint32_t v;
    if (parse_hex_u32(&buf[start], &v) != 0) return -1;
    *crc_out = v;
    return 0;
}

static int try_update_from_sd(void) {
    if (hal_sd_init() != 0) return -1;

    hal_sd_file_t f;
    if (hal_sd_open(&f, SD_FW_PATH) != 0) {
        hal_sd_deinit();
        return -1;
    }

    uint32_t expected_crc = 0;
    int has_expected_crc = (sd_read_crc_file(&expected_crc) == 0);

    uint32_t fw_size = 0;
    if (hal_sd_size(&f, &fw_size) != 0) {
        hal_sd_close(&f);
        hal_sd_deinit();
        return -1;
    }
    if (fw_size == 0 || fw_size > APP_MAX_SIZE) {
        hal_sd_close(&f);
        hal_sd_deinit();
        return -1;
    }

    if (flash_erase_app_region(fw_size) != 0) {
        hal_sd_close(&f);
        hal_sd_deinit();
        return -1;
    }

    uint8_t buf[4096];
    uint32_t addr = APP_BASE;
    uint32_t crc = 0;

    while (1) {
        int rd = hal_sd_read(&f, buf, sizeof(buf));
        if (rd < 0) {
            hal_sd_close(&f);
            hal_sd_deinit();
            return -1;
        }
        if (rd == 0) break;

        crc = crc32_update(crc, buf, (size_t)rd);

        if (flash_program_stream(addr, buf, (size_t)rd) != 0) {
            hal_sd_close(&f);
            hal_sd_deinit();
            return -1;
        }
        addr += (uint32_t)rd;
    }

    hal_sd_close(&f);
    hal_sd_deinit();

    if (has_expected_crc) {
        if (crc != expected_crc) return -1;
    }

    if (!is_valid_app_vector(APP_BASE)) return -1;
    return 0;
}

/* --- UART update (XMODEM-CRC) --- */

#define X_SOH  0x01
#define X_STX  0x02
#define X_EOT  0x04
#define X_ACK  0x06
#define X_NAK  0x15
#define X_CAN  0x18
#define X_C    0x43

static uint16_t crc16_xmodem(const uint8_t *data, size_t len) {
    uint16_t crc = 0;
    for (size_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (int j = 0; j < 8; j++) {
            if (crc & 0x8000) crc = (uint16_t)((crc << 1) ^ 0x1021);
            else crc <<= 1;
        }
    }
    return crc;
}

static int uart_recv_byte_timeout(uint8_t *b, uint32_t timeout_ms) {
    return hal_uart_read(b, 1, timeout_ms) == 1 ? 0 : -1;
}

static void uart_send_byte(uint8_t b) {
    (void)hal_uart_write(&b, 1, 50);
}

static int try_update_from_uart(uint32_t overall_timeout_ms) {
    if (hal_uart_init(UART_BAUD) != 0) return -1;

    uint32_t start_ms = hal_millis();

    /* handshake */
    for (int i = 0; i < 16; i++) {
        uart_send_byte(X_C);
        hal_delay_ms(250);
        if ((hal_millis() - start_ms) > overall_timeout_ms) return -1;
        if (hal_uart_available() > 0) break;
    }

    uint32_t addr = APP_BASE;
    uint32_t crc32 = 0;
    uint32_t total = 0;
    int expected_blk = 1;

    /* erase lazily once we receive first data packet; but need size unknown -> erase whole max for speed tradeoff */
    int erased = 0;

    while (1) {
        uint8_t c;
        if (uart_recv_byte_timeout(&c, 5000) != 0) {
            if ((hal_millis() - start_ms) > overall_timeout_ms) return -1;
            continue;
        }

        if (c == X_EOT) {
            uart_send_byte(X_ACK);
            break;
        }
        if (c == X_CAN) {
            return -1;
        }

        int pkt_len = 0;
        if (c == X_SOH) pkt_len = 128;
        else if (c == X_STX) pkt_len = 1024;
        else {
            continue;
        }

        uint8_t hdr[2];
        if (hal_uart_read(hdr, 2, 1000) != 2) { uart_send_byte(X_NAK); continue; }
        uint8_t blk = hdr[0];
        uint8_t blk_inv = hdr[1];
        if ((uint8_t)(blk + blk_inv) != 0xFFu) { uart_send_byte(X_NAK); continue; }

        uint8_t data[1024];
        if (hal_uart_read(data, (uint32_t)pkt_len, 2000) != pkt_len) { uart_send_byte(X_NAK); continue; }

        uint8_t crcbuf[2];
        if (hal_uart_read(crcbuf, 2, 1000) != 2) { uart_send_byte(X_NAK); continue; }
        uint16_t rx_crc = (uint16_t)((crcbuf[0] << 8) | crcbuf[1]);
        uint16_t calc = crc16_xmodem(data, (size_t)pkt_len);
        if (rx_crc != calc) { uart_send_byte(X_NAK); continue; }

        if (blk == (uint8_t)expected_blk) {
            if (!erased) {
                if (flash_erase_app_region(APP_MAX_SIZE) != 0) return -1;
                erased = 1;
            }

            if ((addr + (uint32_t)pkt_len) > APP_END) { uart_send_byte(X_CAN); uart_send_byte(X_CAN); return -1; }

            crc32 = crc32_update(crc32, data, (size_t)pkt_len);

            if (flash_program_stream(addr, data, (size_t)pkt_len) != 0) {
                uart_send_byte(X_CAN); uart_send_byte(X_CAN);
                return -1;
            }

            addr += (uint32_t)pkt_len;
            total += (uint32_t)pkt_len;
            expected_blk++;
            uart_send_byte(X_ACK);
        } else if (blk == (uint8_t)(expected_blk - 1)) {
            /* duplicate block, ACK again */
            uart_send_byte(X_ACK);
        } else {
            uart_send_byte(X_NAK);
        }
    }

    /* Optional: host may send "CRC32=XXXXXXXX\n" after EOT not handled here */
    (void)crc32;
    (void)total;

    if (!is_valid_app_vector(APP_BASE)) return -1;
    return 0;
}

/* --- Boot entry logic --- */

static int boot_pin_asserted(void) {
    return hal_gpio_boot_pin_asserted(BOOT_PIN_PORT, BOOT_PIN_NUM);
}

static int recovery_magic_set(void) {
    volatile uint32_t *m = (volatile uint32_t*)BL_MAGIC_ADDR;
    if (*m == BL_MAGIC_VALUE) {
        *m = 0;
        return 1;
    }
    return 0;
}

static void system_reset(void) {
    hal_disable_irq();
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    while (1) { }
}

static void bootloader_main(void) {
    hal_platform_init_early();

    int force = 0;
    if (boot_pin_asserted()) force = 1;
    if (recovery_magic_set()) force = 1;

    if (!force && is_valid_app_vector(APP_BASE)) {
        jump_to_app(APP_BASE);
    }

    hal_platform_init();

    /* Try SD first for fast field updates */
    if (try_update_from_sd() == 0) {
        system_reset();
    }

    /* Then UART */
    if (try_update_from_uart(120000) == 0) {
        system_reset();
    }

    /* If no update, jump if possible */
    if (is_valid_app_vector(APP_BASE)) {
        jump_to_app(APP_BASE);
    }

    /* Stay in bootloader waiting for UART */
    while (1) {
        (void)try_update_from_uart(0xFFFFFFFFu);
        if (is_valid_app_vector(APP_BASE)) system_reset();
    }
}

/* Cortex-M reset handler */
void Reset_Handler(void) {
    bootloader_main();
    while (1) { }
}

/* ---------------- Platform HAL (to be implemented per MCU/board) ---------------- */

/* Flash */
int hal_flash_unlock(void);
int hal_flash_lock(void);
int hal_flash_erase_page(uint32_t page_start);
int hal_flash_program(uint32_t addr, const void *data, size_t len);
int hal_flash_get_page_info(uint32_t addr, uint32_t *page_start, uint32_t *page_size);
void hal_flash_deinit(void);

/* UART */
int hal_uart_init(uint32_t baud);
void hal_uart_deinit(void);
int hal_uart_write(const uint8_t *data, uint32_t len, uint32_t timeout_ms);
int hal_uart_read(uint8_t *data, uint32_t len, uint32_t timeout_ms);
uint32_t hal_uart_available(void);

/* SD */
typedef struct hal_sd_file_s { uint32_t opaque[4]; } hal_sd_file_t;
int hal_sd_init(void);
void hal_sd_deinit(void);
int hal_sd_open(hal_sd_file_t *f, const char *path);
int hal_sd_read(hal_sd_file_t *f, uint8_t *buf, uint32_t len);
int hal_sd_size(hal_sd_file_t *f, uint32_t *size_out);
void hal_sd_close(hal_sd_file_t *f);

/* GPIO */
int hal_gpio_boot_pin_asserted(uint32_t port, uint32_t pin);

/* Time */
void hal_delay_ms(uint32_t ms);
uint32_t hal_millis(void);

/* Core */
void hal_platform_init_early(void);
void hal_platform_init(void);
void hal_disable_irq(void);
void hal_systick_deinit(void);
void hal_set_msp(uint32_t msp);
int hal_is_valid_stack(uint32_t sp);

/* Provide weak defaults for link if not supplied */
__attribute__((weak)) int hal_flash_unlock(void){return -1;}
__attribute__((weak)) int hal_flash_lock(void){return -1;}
__attribute__((weak)) int hal_flash_erase_page(uint32_t page_start){(void)page_start;return -1;}
__attribute__((weak)) int hal_flash_program(uint32_t addr, const void *data, size_t len){(void)addr;(void)data;(void)len;return -1;}
__attribute__((weak)) int hal_flash_get_page_info(uint32_t addr, uint32_t *page_start, uint32_t *page_size){(void)addr;(void)page_start;(void)page_size;return -1;}
__attribute__((weak)) void hal_flash_deinit(void){}

__attribute__((weak)) int hal_uart_init(uint32_t baud){(void)baud;return -1;}
__attribute__((weak)) void hal_uart_deinit(void){}
__attribute__((weak)) int hal_uart_write(const uint8_t *data, uint32_t len, uint32_t timeout_ms){(void)data;(void)len;(void)timeout_ms;return -1;}
__attribute__((weak)) int hal_uart_read(uint8_t *data, uint32_t len, uint32_t timeout_ms){(void)data;(void)len;(void)timeout_ms;return -1;}
__attribute__((weak)) uint32_t hal_uart_available(void){return 0;}

__attribute__((weak)) int hal_sd_init(void){return -1;}
__attribute__((weak)) void hal_sd_deinit(void){}
__attribute__((weak)) int hal_sd_open(hal_sd_file_t *f, const char *path){(void)f;(void)path;return -1;}
__attribute__((weak)) int hal_sd_read(hal_sd_file_t *f, uint8_t *buf, uint32_t len){(void)f;(void)buf;(void)len;return -1;}
__attribute__((weak)) int hal_sd_size(hal_sd_file_t *f, uint32_t *size_out){(void)f;(void)size_out;return -1;}
__attribute__((weak)) void hal_sd_close(hal_sd_file_t *f){(void)f;}

__attribute__((weak)) int hal_gpio_boot_pin_asserted(uint32_t port, uint32_t pin){(void)port;(void)pin;return 0;}

__attribute__((weak)) void hal_delay_ms(uint32_t ms){(void)ms;}
__attribute__((weak)) uint32_t hal_millis(void){static uint32_t t; return t++;}

__attribute__((weak)) void hal_platform_init_early(void){}
__attribute__((weak)) void hal_platform_init(void){}
__attribute__((weak)) void hal_disable_irq(void){__asm volatile("cpsid i" ::: "memory");}
__attribute__((weak)) void hal_systick_deinit(void){
    volatile uint32_t *SYST_CSR = (uint32_t*)0xE000E010u;
    volatile uint32_t *SYST_RVR = (uint32_t*)0xE000E014u;
    volatile uint32_t *SYST_CVR = (uint32_t*)0xE000E018u;
    *SYST_CSR = 0;
    *SYST_RVR = 0;
    *SYST_CVR = 0;
}
__attribute__((weak)) void hal_set_msp(uint32_t msp){__asm volatile("msr msp, %0" :: "r"(msp) : "memory");}
__attribute__((weak)) int hal_is_valid_stack(uint32_t sp){
    /* default: accept any SRAM-like stack: 0x2000_0000..0x2008_0000 */
    if (sp < 0x20000000u) return 0;
    if (sp > 0x20080000u) return 0;
    return 1;
}