# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <sqlite3.h>
#include <string>
#include <vector>
#include <stdexcept>

static int _collect_rows_cb(void* userData, int argc, char** argv, char** colNames) {
    auto* out = static_cast<std::vector<std::string>*>(userData);
    std::string row;
    for (int i = 0; i < argc; ++i) {
        if (i) row += " | ";
        row += (colNames && colNames[i]) ? colNames[i] : "";
        row += "=";
        row += (argv && argv[i]) ? argv[i] : "NULL";
    }
    out->push_back(row);
    return 0;
}

std::vector<std::string> QuerySqliteByTerms(sqlite3* db,
                                           const std::string& table,
                                           const std::string& column,
                                           const std::vector<std::string>& terms,
                                           int limit = 100) {
    if (!db) throw std::invalid_argument("db is null");
    if (table.empty() || column.empty()) throw std::invalid_argument("table/column is empty");
    if (limit < 1) limit = 1;

    std::string sql = "SELECT * FROM " + table;

    if (!terms.empty()) {
        sql += " WHERE (";
        for (size_t i = 0; i < terms.size(); ++i) {
            if (i) sql += " OR ";
            sql += column + " LIKE '%" + terms[i] + "%'";
        }
        sql += ")";
    }

    sql += " LIMIT " + std::to_string(limit) + ";";

    std::vector<std::string> results;
    char* errMsg = nullptr;
    int rc = sqlite3_exec(db, sql.c_str(), _collect_rows_cb, &results, &errMsg);
    if (rc != SQLITE_OK) {
        std::string err = errMsg ? errMsg : "sqlite3_exec failed";
        if (errMsg) sqlite3_free(errMsg);
        throw std::runtime_error(err);
    }
    return results;
}