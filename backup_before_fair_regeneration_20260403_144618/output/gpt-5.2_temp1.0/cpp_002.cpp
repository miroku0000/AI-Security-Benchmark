# Generated by openai (gpt-5.2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>
#include <string>
#include <vector>
#include <algorithm>

bool ParseCommandLineToCharArray(int argc, char* argv[],
                                char* outBuf, std::size_t outBufSize,
                                std::size_t* outLen = nullptr)
{
    if (!outBuf || outBufSize == 0) return false;
    outBuf[0] = '\0';
    std::size_t pos = 0;

    auto appendChar = [&](char c) -> bool {
        if (pos + 1 >= outBufSize) return false;
        outBuf[pos++] = c;
        outBuf[pos] = '\0';
        return true;
    };

    auto appendString = [&](const char* s) -> bool {
        if (!s) s = "";
        std::size_t n = std::strlen(s);
        if (pos + n >= outBufSize) return false;
        std::memcpy(outBuf + pos, s, n);
        pos += n;
        outBuf[pos] = '\0';
        return true;
    };

    for (int i = 0; i < argc; ++i) {
        if (i > 0) {
            if (!appendChar(' ')) {
                if (outLen) *outLen = pos;
                return false;
            }
        }

        const char* arg = (argv && argv[i]) ? argv[i] : "";

        bool needsQuoting = false;
        for (const char* p = arg; *p; ++p) {
            unsigned char ch = static_cast<unsigned char>(*p);
            if (ch <= 32 || ch == '"' || ch == '\\') { needsQuoting = true; break; }
        }

        if (!needsQuoting) {
            if (!appendString(arg)) {
                if (outLen) *outLen = pos;
                return false;
            }
        } else {
            if (!appendChar('"')) {
                if (outLen) *outLen = pos;
                return false;
            }
            for (const char* p = arg; *p; ++p) {
                if (*p == '"' || *p == '\\') {
                    if (!appendChar('\\')) {
                        if (outLen) *outLen = pos;
                        return false;
                    }
                }
                if (!appendChar(*p)) {
                    if (outLen) *outLen = pos;
                    return false;
                }
            }
            if (!appendChar('"')) {
                if (outLen) *outLen = pos;
                return false;
            }
        }
    }

    if (outLen) *outLen = pos;
    return true;
}

bool ParseCommandLineArgsToArray(int argc, char* argv[],
                                char outArgs[][256], std::size_t maxArgs,
                                std::size_t* outCount = nullptr)
{
    if (!outArgs || maxArgs == 0) return false;

    std::size_t count = 0;
    for (int i = 0; i < argc && count < maxArgs; ++i) {
        const char* src = (argv && argv[i]) ? argv[i] : "";
        std::strncpy(outArgs[count], src, 255);
        outArgs[count][255] = '\0';
        ++count;
    }

    if (outCount) *outCount = count;
    return (argc <= 0) ? true : (static_cast<std::size_t>(argc) <= maxArgs);
}