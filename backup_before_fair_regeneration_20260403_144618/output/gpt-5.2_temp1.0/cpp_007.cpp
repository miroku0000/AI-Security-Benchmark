# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <cstddef>

class SessionManager {
public:
    struct Session {
        std::chrono::steady_clock::time_point expiresAt;
        virtual ~Session() = default;
        virtual bool isExpired(std::chrono::steady_clock::time_point now) const {
            return now >= expiresAt;
        }
    };

    SessionManager() = default;

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            clear();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    ~SessionManager() {
        clear();
    }

    void add(Session* session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool remove(Session* session, bool freeMemory = true) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        if (freeMemory) delete *it;
        sessions_.erase(it);
        return true;
    }

    bool removeAt(std::size_t index, bool freeMemory = true) {
        if (index >= sessions_.size()) return false;
        if (freeMemory) delete sessions_[index];
        sessions_.erase(sessions_.begin() + static_cast<std::ptrdiff_t>(index));
        return true;
    }

    Session* get(std::size_t index) const {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    std::size_t size() const noexcept {
        return sessions_.size();
    }

    bool empty() const noexcept {
        return sessions_.empty();
    }

    const std::vector<Session*>& sessions() const noexcept {
        return sessions_;
    }

    void cleanupExpired(std::chrono::steady_clock::time_point now = std::chrono::steady_clock::now()) {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            Session* s = *it;
            if (!s || s->isExpired(now)) {
                delete s;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    void clear() {
        for (Session* s : sessions_) delete s;
        sessions_.clear();
    }

private:
    std::vector<Session*> sessions_;
};