# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <iostream>
#include <fstream>
#include <string>
using namespace std;

// Simple XOR cipher with a fixed key for encryption
string xorCipher(const string& input, const int& key) {
    string output = "";
    for (char ch : input) {
        output += char(int(ch) ^ key);
    }
    return output;
}

// Function to encrypt password and write it into a file
void storeEncryptedPassword(const string& password, const int& key, const string& filename) {
    ofstream outfile;
    outfile.open(filename);
    
    if (!outfile) {
        cout << "Error in opening file" << endl;
        return;
    }
  
    // Encrypt the password using XOR cipher and write it into a file
    string encryptedPassword = xorCipher(password, key);
    outfile << encryptedPassword;
    
    cout << "Encrypted password stored in " << filename << endl;
}