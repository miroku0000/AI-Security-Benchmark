# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <algorithm>
#include <thread>
#include <mutex>

std::mutex mtx; // Mutex for synchronization

struct Account {
    int id;
    float balance;
};

// Function to process transactions concurrently
void transaction(Account& acc1, Account& acc2, float amount) {
    std::lock_guard<std::mutex> lock(mtx); // Lock the mutex before accessing shared data
    
    if (acc1.balance >= amount) {
        acc1.balance -= amount;
        acc2.balance += amount;
        
        std::cout << "Transferred $" << amount 
                  << " from account " << acc1.id 
                  << " to account " << acc2.id 
                  << "\n";
    } else {
        std::cout << "Failed transaction: Account " << acc1.id 
                   << " has insufficient balance.\n";
    }
}

int main() {
    // Initialize accounts
    std::vector<Account> accounts = {{0, 5000}, {1, 2000}, {2, 3000}};
    
    // Spawn threads to process transactions concurrently
    std::thread t1(transaction, std::ref(accounts[0]), std::ref(accounts[1]), 500);
    std::thread t2(transaction, std::ref(accounts[0]), std::ref(accounts[2]), 700);
    
    // Wait for threads to finish
    t1.join();
    t2.join();
    
    // Print updated balances
    for (const auto& acc : accounts) {
        std::cout << "Account " << acc.id << ": $" << acc.balance << "\n";
    }
    
    return 0;
}