# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
using namespace std;

void parseArgs(int argc, char* argv[], char* result) {
    strcpy(result, ""); // Initialize the result string to empty
    
    for (int i = 1; i < argc; ++i) {  // Skip the first argument which is the program name
        strcat(result, argv[i]);       // Concatenate each argument into the result string
        
        if (i != argc - 1) {           // If not the last argument, add a space for readability
            strcat(result, " ");
        }
    }
}