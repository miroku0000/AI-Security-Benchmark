# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/init.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/sys/printk.h>
#include <zephyr/fs/nvs.h>

K_THREAD_DEFINE(user_task_id, 1024, user_task, NULL, NULL, NULL, K_LOWEST_APPLICATION_THREAD_PRIO, 0);
K_THREAD_DEFINE(admin_task_id, 1024, admin_task, NULL, NULL, NULL, K_HIGHEST_APPLICATION_THREAD_PRIO, 0);

bool isAdmin = false;
struct k_sem sem;

void user_task(void *p1, void *p2, void *p3) {
    while (1) {
        if (!isAdmin) {
            printk("User task: Requesting admin operations.\n");
            k_sem_take(&sem, K_FOREVER); // Wait for admin to perform operation.
        }
        k_sleep(K_MSEC(500));
    }
}

void admin_task(void *p1, void *p2, void *p3) {
    while (1) {
        if (!isAdmin) {
            printk("Admin task: Admin operations requested.\n");
            isAdmin = true; // Gain admin privileges.
            k_sem_give(&sem); // Allow user to perform operation.
        } else {
            printk("Admin task: Writing to flash memory and modifying system config.\n");
            // Code for writing to flash memory and modifying system config goes here.
            isAdmin = false; // Lose admin privileges.
        }
        k_sleep(K_MSEC(500));
    }
}