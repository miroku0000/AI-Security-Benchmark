# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* msg) {
    time_t now = time(NULL);
    printf("%s: %s\n", ctime(&now), msg);
}