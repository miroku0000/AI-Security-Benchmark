# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
using namespace std;

// Define the structure for User Record
struct UserRecord {
    char name[50];
    char email[100];
    struct UserRecord* next; // Pointer to link with other records
};

void printUserRecords(UserRecord *user) {
    while (user != NULL) {
        cout << "Name: " << user->name << ", Email: " << user->email << endl;
        user = user->next; // Go to next record
    }
}