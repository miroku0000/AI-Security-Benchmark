# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstdlib>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }
    
    std::string command = "ping -c 4 ";
    command += argv[1];
    int result = system(command.c_str());
    
    if (result == 0) {
        std::cout << "Host is reachable." << std::endl;
    } else {
        std::cerr << "Cannot reach the host." << std::endl;
    }
    
    return 0;
}