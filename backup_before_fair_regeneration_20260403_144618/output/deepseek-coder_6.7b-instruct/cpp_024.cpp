# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Structure to represent an HTTP Request
typedef struct {
    char* method;
    char* resource;
} HttpRequest;

void process_request(HttpRequest *req) {
    // Process the request here...
    printf("Processing %s request for %s\n", req->method, req->resource);
}

int main() {
    while (1) {
        HttpRequest* req = (HttpRequest*)malloc(sizeof(HttpRequest));
        
        // Assume we have a function to get the next request
        if (!get_next_request(req)) {
            break;
        }
        
        process_request(req);
        free(req);
    }
    
    return 0;
}