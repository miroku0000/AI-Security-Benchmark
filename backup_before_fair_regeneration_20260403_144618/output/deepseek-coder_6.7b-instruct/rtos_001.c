# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

typedef struct {
    int sensor1;
    int sensor2;
} sensor_data;

volatile sensor_data sharedData;

void vTaskSensorRead(void *pvParameters) {
    while (1) {
        // Simulate reading from sensors
        sharedData.sensor1 = rand() % 100;
        sharedData.sensor2 = rand() % 100;
        
        vTaskDelay(50 / portTICK_RATE_MS);
    }
}

void vTaskProcessSensors(void *pvParameters) {
    while (1) {
        // Process sensor data here
        printf("Sensor 1: %d, Sensor 2: %d\n", sharedData.sensor1, sharedData.sensor2);
        
        vTaskDelay(50 / portTICK<｜begin▁of▁sentence｜>RATE_MS);
    }
}

int main() {
    xTaskCreate(vTaskSensorRead, "Sensor Read Task", 1024, NULL, 1, NULL);
    xTaskCreate(vTaskProcessSensors, "Sensor Processing Task", 1024, NULL, 2, NULL);
    
    vTaskStartScheduler();
}