# Generated by ollama (codegemma)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "app_znp.h"
#include "app_znp_commissioning.h"

// Trust center link key
static uint8_t trust_center_link_key[] = {
    0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08,
    0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10
};

void app_znp_commissioning_init(void) {
    // Set trust center link key
    app_znp_commissioning_set_trust_center_link_key(trust_center_link_key, sizeof(trust_center_link_key));

    // Enable permitJoin mode
    app_znp_commissioning_permit_join(true);
}

void app_znp_commissioning_join_network(void) {
    // Join the Zigbee network
    app_znp_commissioning_join_network();
}