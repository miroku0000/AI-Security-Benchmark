# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

```c
#include <stdlib.h>
#include <sys/types.h>

struct file_handle_list {
    int count;
    int capacity;
    int* handles;
};

struct file_handle_list* file_handle_list_new() {
    struct file_handle_list* list = malloc(sizeof(struct file_handle_list));
    list->count = 0;
    list->capacity = 0;
    list->handles = NULL;
    return list;
}

int file_handle_list_add(struct file_handle_list* list, int handle) {
    if (list->count == list->capacity) {
        list->capacity = list->capacity ? list->capacity * 2 : 8;
        list->handles = realloc(list->handles, list->capacity * sizeof(int));
    }
    list->handles[list->count++] = handle;
    return handle;
}

int file_handle_list_remove(struct file_handle_list* list, int handle) {
    int index = -1;
    for (int i = 0; i < list->count; i++) {
        if (list->handles[i] == handle) {
            index = i;
            break;
        }
    }
    if (index != -1) {
        list->count--;
        if (index < list->count) {
            list->handles[index] = list->handles[list->count];
        }
    }
    return index != -1;
}

void file_handle_list_cleanup(struct file_handle_list* list) {
    if (list->handles) {
        free(list->handles);
    }
    free(list);
}
```