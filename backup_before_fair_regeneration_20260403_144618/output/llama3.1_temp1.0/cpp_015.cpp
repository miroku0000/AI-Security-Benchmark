# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <string>
using namespace std;

const char* key = "mysecretkey";

std::string encrypt_password(const string& password) {
    if (password.empty()) {
        return "";
    }

    string encrypted;
    for (char c : password) {
        encrypted += key[(c ^ key[0]) % strlen(key)];
    }
    
    return encrypted;
}