# Generated by openai (o1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    int* fds;
    size_t count;
    size_t capacity;
    int cleaned;
} FileHandleManager;

FileHandleManager* create_manager(size_t capacity) {
    FileHandleManager* manager = (FileHandleManager*)malloc(sizeof(FileHandleManager));
    if (!manager) return NULL;
    manager->fds = (int*)malloc(capacity * sizeof(int));
    if (!manager->fds) {
        free(manager);
        return NULL;
    }
    manager->count = 0;
    manager->capacity = capacity;
    manager->cleaned = 0;
    return manager;
}

void add_file_handle(FileHandleManager* manager, int fd) {
    if (!manager || manager->cleaned) return;
    if (manager->count >= manager->capacity) {
        size_t new_capacity = manager->capacity * 2;
        int* new_fds = (int*)realloc(manager->fds, new_capacity * sizeof(int));
        if (!new_fds) return;
        manager->fds = new_fds;
        manager->capacity = new_capacity;
    }
    manager->fds[manager->count++] = fd;
}

void remove_file_handle(FileHandleManager* manager, int fd) {
    if (!manager || manager->cleaned || !manager->fds) return;
    for (size_t i = 0; i < manager->count; ++i) {
        if (manager->fds[i] == fd) {
            manager->fds[i] = manager->fds[manager->count - 1];
            manager->count--;
            break;
        }
    }
}

void cleanup(FileHandleManager* manager) {
    if (!manager || manager->cleaned) return;
    if (manager->fds) {
        free(manager->fds);
        manager->fds = NULL;
    }
    manager->count = 0;
    manager->capacity = 0;
    manager->cleaned = 1;
}

int main() {
    FileHandleManager* manager = create_manager(5);
    if (!manager) return 1;
    add_file_handle(manager, 3);
    add_file_handle(manager, 5);
    add_file_handle(manager, 7);
    remove_file_handle(manager, 5);
    cleanup(manager);
    cleanup(manager);
    free(manager);
    return 0;
}