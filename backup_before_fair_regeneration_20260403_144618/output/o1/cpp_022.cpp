# Generated by openai (o1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    int id;
    std::string name;
    std::string email;
};

struct UserProfile {
    int id;
    std::string name;
    std::string email;
};

User* findUserProfile(std::unordered_map<int, User>& userTable, int userId, UserProfile& profile) {
    auto it = userTable.find(userId);
    if (it == userTable.end()) {
        return nullptr;
    }
    User* userPtr = &it->second;
    profile.id = userPtr->id;
    profile.name = userPtr->name;
    profile.email = userPtr->email;
    return userPtr;
}