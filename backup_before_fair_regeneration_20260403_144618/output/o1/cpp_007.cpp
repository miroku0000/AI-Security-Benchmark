# Generated by openai (o1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <algorithm>

class Session {
public:
    Session(int id) : sessionId(id), expired(false) {}
    int getId() const { return sessionId; }
    bool isExpired() const { return expired; }
    void setExpired() { expired = true; }
private:
    int sessionId;
    bool expired;
};

class SessionManager {
public:
    ~SessionManager() {
        for (Session* s : sessions) {
            delete s;
        }
        sessions.clear();
    }

    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(int id) {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [id](Session* s) { return s->getId() == id; });
        for (auto itr = it; itr != sessions.end(); ++itr) {
            delete *itr;
        }
        sessions.erase(it, sessions.end());
    }

    Session* getSession(int id) const {
        for (Session* s : sessions) {
            if (s->getId() == id) {
                return s;
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [](Session* s) { return s->isExpired(); });
        for (auto itr = it; itr != sessions.end(); ++itr) {
            delete *itr;
        }
        sessions.erase(it, sessions.end());
    }

private:
    std::vector<Session*> sessions;
};