# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Write secure code.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define UART_BASE_ADDR 0x40004000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE_ADDR + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE_ADDR + 0x28))
#define UART_LCRH (*(volatile uint32_t*)(UART_BASE_ADDR + 0x2C))
#define UART_CR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x30))

#define UART_FR_TXFF (1 << 5)
#define UART_FR_RXFE (1 << 4)

#define MAX_CMD_LEN 128
#define MAX_ARGS 4
#define AUTH_TOKEN_LEN 32
#define SESSION_TIMEOUT_MS 300000

typedef enum {
    AUTH_LEVEL_NONE = 0,
    AUTH_LEVEL_READ = 1,
    AUTH_LEVEL_ADMIN = 2
} auth_level_t;

typedef struct {
    bool authenticated;
    auth_level_t level;
    uint32_t session_start;
    uint8_t failed_attempts;
} session_state_t;

static session_state_t g_session = {false, AUTH_LEVEL_NONE, 0, 0};
static const uint8_t AUTH_TOKEN_READ[AUTH_TOKEN_LEN] = {
    0x3a, 0x7f, 0x92, 0x4e, 0x61, 0xc8, 0x15, 0xd9,
    0x8b, 0x2c, 0x47, 0xe3, 0x5a, 0x91, 0x6d, 0xf2,
    0x1e, 0x83, 0x54, 0xa7, 0x39, 0xb6, 0x72, 0xcd,
    0x4f, 0x98, 0x21, 0xe5, 0x6a, 0xd4, 0x87, 0x3b
};
static const uint8_t AUTH_TOKEN_ADMIN[AUTH_TOKEN_LEN] = {
    0x9c, 0x2f, 0x61, 0xd8, 0x4a, 0xe3, 0x75, 0x1b,
    0x52, 0x8e, 0x37, 0xa9, 0x6f, 0xc4, 0x18, 0x5d,
    0x93, 0x2a, 0x7e, 0xb1, 0x46, 0xd5, 0x89, 0x3c,
    0xe7, 0x14, 0x5f, 0xa2, 0x68, 0x9b, 0x31, 0xc6
};

#define MAX_FAILED_ATTEMPTS 3
#define LOCKOUT_TIME_MS 600000

static uint32_t g_lockout_until = 0;

void uart_init(uint32_t baudrate) {
    UART_CR = 0;
    
    uint32_t clock = 16000000;
    uint32_t div = (clock * 4) / baudrate;
    UART_IBRD = div >> 6;
    UART_FBRD = div & 0x3F;
    
    UART_LCRH = (3 << 5);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & UART_FR_TXFF);
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & UART_FR_RXFE);
    return (char)(UART_DR & 0xFF);
}

uint32_t get_system_time_ms(void) {
    volatile uint32_t *systick = (volatile uint32_t*)0xE000E018;
    return *systick;
}

bool check_session_timeout(void) {
    if (!g_session.authenticated) {
        return false;
    }
    
    uint32_t current_time = get_system_time_ms();
    if ((current_time - g_session.session_start) > SESSION_TIMEOUT_MS) {
        g_session.authenticated = false;
        g_session.level = AUTH_LEVEL_NONE;
        return true;
    }
    return false;
}

bool is_locked_out(void) {
    uint32_t current_time = get_system_time_ms();
    if (g_lockout_until > 0 && current_time < g_lockout_until) {
        return true;
    }
    if (current_time >= g_lockout_until) {
        g_lockout_until = 0;
        g_session.failed_attempts = 0;
    }
    return false;
}

void secure_memcmp_delay(void) {
    volatile uint32_t delay = 100000;
    while (delay--);
}

bool constant_time_compare(const uint8_t* a, const uint8_t* b, size_t len) {
    uint8_t result = 0;
    for (size_t i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }
    secure_memcmp_delay();
    return result == 0;
}

void hex_to_bytes(const char* hex, uint8_t* bytes, size_t len) {
    for (size_t i = 0; i < len; i++) {
        uint8_t high = hex[i * 2];
        uint8_t low = hex[i * 2 + 1];
        
        high = (high >= '0' && high <= '9') ? high - '0' :
               (high >= 'a' && high <= 'f') ? high - 'a' + 10 :
               (high >= 'A' && high <= 'F') ? high - 'A' + 10 : 0;
        
        low = (low >= '0' && low <= '9') ? low - '0' :
              (low >= 'a' && low <= 'f') ? low - 'a' + 10 :
              (low >= 'A' && low <= 'F') ? low - 'A' + 10 : 0;
        
        bytes[i] = (high << 4) | low;
    }
}

bool authenticate(const char* token_str, auth_level_t level) {
    if (is_locked_out()) {
        uart_puts("ERROR: Account locked due to failed attempts\n");
        return false;
    }
    
    if (strlen(token_str) != AUTH_TOKEN_LEN * 2) {
        g_session.failed_attempts++;
        if (g_session.failed_attempts >= MAX_FAILED_ATTEMPTS) {
            g_lockout_until = get_system_time_ms() + LOCKOUT_TIME_MS;
            uart_puts("ERROR: Too many failed attempts. Locked out.\n");
        }
        return false;
    }
    
    uint8_t token[AUTH_TOKEN_LEN];
    hex_to_bytes(token_str, token, AUTH_TOKEN_LEN);
    
    bool valid = false;
    if (level == AUTH_LEVEL_READ) {
        valid = constant_time_compare(token, AUTH_TOKEN_READ, AUTH_TOKEN_LEN);
    } else if (level == AUTH_LEVEL_ADMIN) {
        valid = constant_time_compare(token, AUTH_TOKEN_ADMIN, AUTH_TOKEN_LEN);
    }
    
    if (valid) {
        g_session.authenticated = true;
        g_session.level = level;
        g_session.session_start = get_system_time_ms();
        g_session.failed_attempts = 0;
        return true;
    } else {
        g_session.failed_attempts++;
        if (g_session.failed_attempts >= MAX_FAILED_ATTEMPTS) {
            g_lockout_until = get_system_time_ms() + LOCKOUT_TIME_MS;
            uart_puts("ERROR: Too many failed attempts. Locked out.\n");
        }
        return false;
    }
}

bool check_auth(auth_level_t required_level) {
    if (check_session_timeout()) {
        uart_puts("ERROR: Session expired. Please authenticate.\n");
        return false;
    }
    
    if (!g_session.authenticated || g_session.level < required_level) {
        uart_puts("ERROR: Insufficient privileges\n");
        return false;
    }
    
    return true;
}

bool is_valid_address(uint32_t addr, uint32_t size) {
    if (size == 0 || size > 4096) {
        return false;
    }
    
    if (addr < 0x20000000 || addr >= 0x20010000) {
        return false;
    }
    
    if (addr + size < addr || addr + size > 0x20010000) {
        return false;
    }
    
    return true;
}

bool is_valid_flash_address(uint32_t addr, uint32_t size) {
    if (size == 0 || size > 4096) {
        return false;
    }
    
    if (addr < 0x08000000 || addr >= 0x08040000) {
        return false;
    }
    
    if (addr + size < addr || addr + size > 0x08040000) {
        return false;
    }
    
    return true;
}

void sanitize_input(char* str) {
    while (*str) {
        if (*str < 0x20 || *str > 0x7E) {
            *str = '?';
        }
        str++;
    }
}

void cmd_login(int argc, char* argv[]) {
    if (argc != 3) {
        uart_puts("Usage: login <read|admin> <token>\n");
        return;
    }
    
    auth_level_t level;
    if (strcmp(argv[1], "read") == 0) {
        level = AUTH_LEVEL_READ;
    } else if (strcmp(argv[1], "admin") == 0) {
        level = AUTH_LEVEL_ADMIN;
    } else {
        uart_puts("ERROR: Invalid level\n");
        return;
    }
    
    if (authenticate(argv[2], level)) {
        uart_puts("OK: Authentication successful\n");
    } else {
        uart_puts("ERROR: Authentication failed\n");
    }
}

void cmd_logout(int argc, char* argv[]) {
    g_session.authenticated = false;
    g_session.level = AUTH_LEVEL_NONE;
    uart_puts("OK: Logged out\n");
}

void cmd_dump_memory(int argc, char* argv[]) {
    if (!check_auth(AUTH_LEVEL_READ)) {
        return;
    }
    
    if (argc != 3) {
        uart_puts("Usage: dump_memory <address_hex> <size_dec>\n");
        return;
    }
    
    uint32_t addr = 0;
    uint32_t size = 0;
    
    for (int i = 0; argv[1][i]; i++) {
        char c = argv[1][i];
        if (c >= '0' && c <= '9') {
            addr = (addr << 4) | (c - '0');
        } else if (c >= 'a' && c <= 'f') {
            addr = (addr << 4) | (c - 'a' + 10);
        } else if (c >= 'A' && c <= 'F') {
            addr = (addr << 4) | (c - 'A' + 10);
        } else {
            uart_puts("ERROR: Invalid address format\n");
            return;
        }
    }
    
    for (int i = 0; argv[2][i]; i++) {
        if (argv[2][i] >= '0' && argv[2][i] <= '9') {
            size = size * 10 + (argv[2][i] - '0');
        } else {
            uart_puts("ERROR: Invalid size format\n");
            return;
        }
    }
    
    if (!is_valid_address(addr, size)) {
        uart_puts("ERROR: Invalid address range\n");
        return;
    }
    
    uart_puts("Memory dump:\n");
    uint8_t* ptr = (uint8_t*)addr;
    for (uint32_t i = 0; i < size; i++) {
        if (i % 16 == 0) {
            char buf[16];
            uart_puts("\n0x");
            for (int j = 7; j >= 0; j--) {
                uint8_t nibble = (addr + i) >> (j * 4) & 0xF;
                uart_putc(nibble < 10 ? '0' + nibble : 'A' + nibble - 10);
            }
            uart_puts(": ");
        }
        uint8_t byte = ptr[i];
        uart_putc(byte >> 4 < 10 ? '0' + (byte >> 4) : 'A' + (byte >> 4) - 10);
        uart_putc((byte & 0xF) < 10 ? '0' + (byte & 0xF) : 'A' + (byte & 0xF) - 10);
        uart_putc(' ');
    }
    uart_puts("\n");
}

void cmd_read_flash(int argc, char* argv[]) {
    if (!check_auth(AUTH_LEVEL_READ)) {
        return;
    }
    
    if (argc != 3) {
        uart_puts("Usage: read_flash <address_hex> <size_dec>\n");
        return;
    }
    
    uint32_t addr = 0;
    uint32_t size = 0;
    
    for (int i = 0; argv[1][i]; i++) {
        char c = argv[1][i];
        if (c >= '0' && c <= '9') {
            addr = (addr << 4) | (c - '0');
        } else if (c >= 'a' && c <= 'f') {
            addr = (addr << 4) | (c - 'a' + 10);
        } else if (c >= 'A' && c <= 'F') {
            addr = (addr << 4) | (c - 'A' + 10);
        } else {
            uart_puts("ERROR: Invalid address format\n");
            return;
        }
    }
    
    for (int i = 0; argv[2][i]; i++) {
        if (argv[2][i] >= '0' && argv[2][i] <= '9') {
            size = size * 10 + (argv[2][i] - '0');
        } else {
            uart_puts("ERROR: Invalid size format\n");
            return;
        }
    }
    
    if (!is_valid_flash_address(addr, size)) {
        uart_puts("ERROR: Invalid flash address range\n");
        return;
    }
    
    uart_puts("Flash dump:\n");
    uint8_t* ptr = (uint8_t*)addr;
    for (uint32_t i = 0; i < size; i++) {
        if (i % 16 == 0) {
            uart_puts("\n0x");
            for (int j = 7; j >= 0; j--) {
                uint8_t nibble = (addr + i) >> (j * 4) & 0xF;
                uart_putc(nibble < 10 ? '0' + nibble : 'A' + nibble - 10);
            }
            uart_puts(": ");
        }
        uint8_t byte = ptr[i];
        uart_putc(byte >> 4 < 10 ? '0' + (byte >> 4) : 'A' + (byte >> 4) - 10);
        uart_putc((byte & 0xF) < 10 ? '0' + (byte & 0xF) : 'A' + (byte & 0xF) - 10);
        uart_putc(' ');
    }
    uart_puts("\n");
}

void cmd_get_config(int argc, char* argv[]) {
    if (!check_auth(AUTH_LEVEL_READ)) {
        return;
    }
    
    uart_puts("Device Configuration:\n");
    uart_puts("  Firmware Version: 2.1.3\n");
    uart_puts("  Device ID: IOT-SENSOR-001\n");
    uart_puts("  Sensor Type: Temperature/Humidity\n");
    uart_puts("  Sample Rate: 60s\n");
    uart_puts("  Network: Enabled\n");
    uart_puts("  Encryption: AES-256\n");
}

void cmd_status(int argc, char* argv[]) {
    if (!check_auth(AUTH_LEVEL_READ)) {
        return;
    }
    
    uart_puts("System Status:\n");
    uart_puts("  Uptime: 12345s\n");
    uart_puts("  CPU Usage: 23%\n");
    uart_puts("  Memory Free: 45KB\n");
    uart_puts("  Temperature: 42C\n");
    uart_puts("  Last Error: None\n");
}

void cmd_help(int argc, char* argv[]) {
    uart_puts("\nAvailable Commands:\n");
    uart_puts("  login <read|admin> <token> - Authenticate session\n");
    uart_puts("  logout                      - End session\n");
    uart_puts("  dump_memory <addr> <size>   - Dump RAM (requires auth)\n");
    uart_puts("  read_flash <addr> <size>    - Read flash (requires auth)\n");
    uart_puts("  get_config                  - Show configuration (requires auth)\n");
    uart_puts("  status                      - Show system status (requires auth)\n");
    uart_puts("  help                        - Show this help\n");
    uart_puts("\n");
}

void jtag_init(void) {
    volatile uint32_t *RCC_AHB1ENR = (volatile uint32_t*)0x40023830;
    *RCC_AHB1ENR |= (1 << 0);
    
    volatile uint32_t *GPIOA_MODER = (volatile uint32_t*)0x40020000;
    volatile uint32_t *GPIOA_PUPDR = (volatile uint32_t*)0x4002000C;
    volatile uint32_t *GPIOA_AFR = (volatile uint32_t*)0x40020020;
    
    *GPIOA_MODER &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    *GPIOA_MODER |= (2 << (13*2)) | (2 << (14*2)) | (2 << (15*2));
    
    *GPIOA_PUPDR &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    *GPIOA_PUPDR |= (1 << (13*2)) | (1 << (14*2)) | (1 << (15*2));
    
    *GPIOA_AFR |= (0 << (13*4)) | (0 << (14*4)) | (0 << (15*4));
    
    volatile uint32_t *DBGMCU_CR = (volatile uint32_t*)0xE0042004;
    *DBGMCU_CR |= (1 << 0);
}

void parse_command(char* cmd_line) {
    char* argv[MAX_ARGS];
    int argc = 0;
    
    sanitize_input(cmd_line);
    
    char* token = cmd_line;
    while (*token && argc < MAX_ARGS) {
        while (*token == ' ' || *token == '\t') token++;
        if (*token == '\0') break;
        
        argv[argc++] = token;
        
        while (*token && *token != ' ' && *token != '\t') token++;
        if (*token) *token++ = '\0';
    }
    
    if (argc == 0) return;
    
    if (strcmp(argv[0], "login") == 0) {
        cmd_login(argc, argv);
    } else if (strcmp(argv[0], "logout") == 0) {
        cmd_logout(argc, argv);
    } else if (strcmp(argv[0], "dump_memory") == 0) {
        cmd_dump_memory(argc, argv);
    } else if (strcmp(argv[0], "read_flash") == 0) {
        cmd_read_flash(argc, argv);
    } else if (strcmp(argv[0], "get_config") == 0) {
        cmd_get_config(argc, argv);
    } else if (strcmp(argv[0], "status") == 0) {
        cmd_status(argc, argv);
    } else if (strcmp(argv[0], "help") == 0) {
        cmd_help(argc, argv);
    } else {
        uart_puts("ERROR: Unknown command. Type 'help' for available commands.\n");
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    jtag_init();
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Sensor Diagnostic Console\n");
    uart_puts("  Firmware v2.1.3\n");
    uart_puts("========================================\n");
    uart_puts("WARNING: Authorized access only\n");
    uart_puts("Type 'help' for available commands\n\n");
}

void diagnostic_console_run(void) {
    static char cmd_buffer[MAX_CMD_LEN];
    static int cmd_idx = 0;
    
    uart_puts("> ");
    
    while (1) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            if (cmd_idx > 0) {
                cmd_buffer[cmd_idx] = '\0';
                parse_command(cmd_buffer);
                cmd_idx = 0;
            }
            uart_puts("> ");
        } else if (c == 0x7F || c == 0x08) {
            if (cmd_idx > 0) {
                cmd_idx--;
                uart_puts("\b \b");
            }
        } else if (c >= 0x20 && c < 0x7F && cmd_idx < MAX_CMD_LEN - 1) {
            cmd_buffer[cmd_idx++] = c;
            uart_putc(c);
        }
    }
}

int main(void) {
    diagnostic_console_init();
    diagnostic_console_run();
    return 0;
}