# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>
#include <atomic>

class BankAccount {
private:
    std::string accountId;
    double balance;
    mutable std::shared_mutex mutex;

public:
    BankAccount(const std::string& id, double initialBalance) 
        : accountId(id), balance(initialBalance) {}

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    double getBalance() const {
        std::shared_lock<std::shared_mutex> lock(mutex);
        return balance;
    }

    std::string getAccountId() const {
        return accountId;
    }
};

class Bank {
private:
    std::unordered_map<std::string, BankAccount*> accounts;
    mutable std::shared_mutex bankMutex;

public:
    ~Bank() {
        for (auto& pair : accounts) {
            delete pair.second;
        }
    }

    bool createAccount(const std::string& accountId, double initialBalance) {
        if (initialBalance < 0) return false;
        
        std::unique_lock<std::shared_mutex> lock(bankMutex);
        if (accounts.find(accountId) != accounts.end()) {
            return false;
        }
        accounts[accountId] = new BankAccount(accountId, initialBalance);
        return true;
    }

    bool deposit(const std::string& accountId, double amount) {
        std::shared_lock<std::shared_mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            return false;
        }
        return it->second->deposit(amount);
    }

    bool withdraw(const std::string& accountId, double amount) {
        std::shared_lock<std::shared_mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            return false;
        }
        return it->second->withdraw(amount);
    }

    bool transfer(const std::string& fromAccountId, const std::string& toAccountId, double amount) {
        if (amount <= 0 || fromAccountId == toAccountId) return false;

        std::shared_lock<std::shared_mutex> lock(bankMutex);
        auto fromIt = accounts.find(fromAccountId);
        auto toIt = accounts.find(toAccountId);
        
        if (fromIt == accounts.end() || toIt == accounts.end()) {
            return false;
        }

        BankAccount* fromAccount = fromIt->second;
        BankAccount* toAccount = toIt->second;

        if (fromAccount < toAccount) {
            if (fromAccount->withdraw(amount)) {
                toAccount->deposit(amount);
                return true;
            }
        } else {
            if (fromAccount->withdraw(amount)) {
                toAccount->deposit(amount);
                return true;
            }
        }
        return false;
    }

    double getBalance(const std::string& accountId) const {
        std::shared_lock<std::shared_mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            return -1.0;
        }
        return it->second->getBalance();
    }

    double getTotalBalance() const {
        std::shared_lock<std::shared_mutex> lock(bankMutex);
        double total = 0.0;
        for (const auto& pair : accounts) {
            total += pair.second->getBalance();
        }
        return total;
    }

    size_t getAccountCount() const {
        std::shared_lock<std::shared_mutex> lock(bankMutex);
        return accounts.size();
    }
};

std::atomic<int> successfulTransactions(0);
std::atomic<int> failedTransactions(0);

void processTransactions(Bank& bank, const std::vector<std::string>& accountIds, int numTransactions, int threadId) {
    std::random_device rd;
    std::mt19937 gen(rd() + threadId);
    std::uniform_int_distribution<> accountDist(0, accountIds.size() - 1);
    std::uniform_int_distribution<> operationDist(0, 2);
    std::uniform_real_distribution<> amountDist(1.0, 100.0);

    for (int i = 0; i < numTransactions; ++i) {
        int operation = operationDist(gen);
        std::string accountId = accountIds[accountDist(gen)];
        double amount = amountDist(gen);

        bool success = false;
        switch (operation) {
            case 0:
                success = bank.deposit(accountId, amount);
                break;
            case 1:
                success = bank.withdraw(accountId, amount);
                break;
            case 2: {
                std::string toAccountId = accountIds[accountDist(gen)];
                success = bank.transfer(accountId, toAccountId, amount);
                break;
            }
        }

        if (success) {
            successfulTransactions++;
        } else {
            failedTransactions++;
        }
    }
}

void readBalances(Bank& bank, const std::vector<std::string>& accountIds, int numReads, int threadId) {
    std::random_device rd;
    std::mt19937 gen(rd() + threadId);
    std::uniform_int_distribution<> accountDist(0, accountIds.size() - 1);

    for (int i = 0; i < numReads; ++i) {
        std::string accountId = accountIds[accountDist(gen)];
        double balance = bank.getBalance(accountId);
        std::this_thread::sleep_for(std::chrono::microseconds(10));
    }
}

int main() {
    Bank bank;
    
    const int NUM_ACCOUNTS = 10;
    const int INITIAL_BALANCE = 1000;
    std::vector<std::string> accountIds;

    for (int i = 0; i < NUM_ACCOUNTS; ++i) {
        std::string accountId = "ACC" + std::to_string(1000 + i);
        bank.createAccount(accountId, INITIAL_BALANCE);
        accountIds.push_back(accountId);
    }

    double initialTotal = bank.getTotalBalance();
    std::cout << "Initial total balance: $" << std::fixed << std::setprecision(2) << initialTotal << std::endl;

    const int NUM_TRANSACTION_THREADS = 4;
    const int NUM_READ_THREADS = 2;
    const int TRANSACTIONS_PER_THREAD = 1000;
    const int READS_PER_THREAD = 500;

    std::vector<std::thread> threads;

    auto startTime = std::chrono::high_resolution_clock::now();

    for (int i = 0; i < NUM_TRANSACTION_THREADS; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), std::cref(accountIds), TRANSACTIONS_PER_THREAD, i);
    }

    for (int i = 0; i < NUM_READ_THREADS; ++i) {
        threads.emplace_back(readBalances, std::ref(bank), std::cref(accountIds), READS_PER_THREAD, i + NUM_TRANSACTION_THREADS);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    auto endTime = std::chrono::high_resolution_clock::now();
    auto duration = std::chrono::duration_cast<std::chrono::milliseconds>(endTime - startTime);

    double finalTotal = bank.getTotalBalance();
    
    std::cout << "\nFinal total balance: $" << std::fixed << std::setprecision(2) << finalTotal << std::endl;
    std::cout << "Balance difference: $" << (finalTotal - initialTotal) << std::endl;
    std::cout << "Successful transactions: " << successfulTransactions.load() << std::endl;
    std::cout << "Failed transactions: " << failedTransactions.load() << std::endl;
    std::cout << "Execution time: " << duration.count() << " ms" << std::endl;

    std::cout << "\nIndividual account balances:" << std::endl;
    for (const auto& accountId : accountIds) {
        std::cout << accountId << ": $" << std::fixed << std::setprecision(2) << bank.getBalance(accountId) << std::endl;
    }

    return 0;
}