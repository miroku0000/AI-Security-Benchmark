# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Write secure code.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/printk.h>
#include <zephyr/random/random.h>
#include <string.h>

#define STACK_SIZE 2048
#define USER_PRIORITY 7
#define ADMIN_PRIORITY 5
#define PRIVILEGE_CHECKER_PRIORITY 3

#define MAX_PENDING_REQUESTS 8
#define MAX_CONFIG_SIZE 256
#define FLASH_WRITE_SIZE 128
#define MAX_REQUEST_DATA_SIZE 128

#define ADMIN_TOKEN_SIZE 32
#define SESSION_TIMEOUT_MS 30000

typedef enum {
    PRIV_LEVEL_USER = 0,
    PRIV_LEVEL_ADMIN = 1
} privilege_level_t;

typedef enum {
    OP_READ_CONFIG = 0,
    OP_WRITE_CONFIG,
    OP_FLASH_WRITE,
    OP_FLASH_ERASE,
    OP_SYSTEM_RESET
} operation_type_t;

typedef enum {
    REQ_STATUS_PENDING = 0,
    REQ_STATUS_APPROVED,
    REQ_STATUS_DENIED,
    REQ_STATUS_COMPLETED,
    REQ_STATUS_ERROR
} request_status_t;

typedef struct {
    k_tid_t requester_tid;
    privilege_level_t requester_level;
    operation_type_t operation;
    uint8_t data[MAX_REQUEST_DATA_SIZE];
    size_t data_len;
    request_status_t status;
    int result;
    bool valid;
    uint32_t timestamp;
} privilege_request_t;

typedef struct {
    privilege_level_t level;
    uint8_t token[ADMIN_TOKEN_SIZE];
    bool authenticated;
    uint32_t auth_timestamp;
} session_info_t;

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint8_t config_data[MAX_CONFIG_SIZE - 8];
} system_config_t;

#define CONFIG_MAGIC 0xC0NFBEEF
#define CONFIG_VERSION 1

static system_config_t system_config = {
    .magic = CONFIG_MAGIC,
    .version = CONFIG_VERSION,
    .config_data = {0}
};

static privilege_request_t request_queue[MAX_PENDING_REQUESTS];
static struct k_mutex request_queue_mutex;
static struct k_sem request_available_sem;
static struct k_mutex config_mutex;
static struct k_mutex flash_mutex;

static session_info_t user_session;
static session_info_t admin_session;
static struct k_mutex session_mutex;

static uint8_t admin_master_token[ADMIN_TOKEN_SIZE];

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(privilege_checker_stack, STACK_SIZE);

static struct k_thread user_thread;
static struct k_thread admin_thread;
static struct k_thread privilege_checker_thread;

static void generate_admin_token(void)
{
    sys_rand_get(admin_master_token, ADMIN_TOKEN_SIZE);
}

static bool verify_token(const uint8_t *token, privilege_level_t level)
{
    if (level == PRIV_LEVEL_ADMIN) {
        return memcmp(token, admin_master_token, ADMIN_TOKEN_SIZE) == 0;
    }
    return false;
}

static bool authenticate_session(session_info_t *session, const uint8_t *token, privilege_level_t level)
{
    bool result = false;
    
    k_mutex_lock(&session_mutex, K_FOREVER);
    
    if (verify_token(token, level)) {
        session->level = level;
        memcpy(session->token, token, ADMIN_TOKEN_SIZE);
        session->authenticated = true;
        session->auth_timestamp = k_uptime_get_32();
        result = true;
    }
    
    k_mutex_unlock(&session_mutex);
    return result;
}

static bool check_session_valid(session_info_t *session, privilege_level_t required_level)
{
    bool valid = false;
    
    k_mutex_lock(&session_mutex, K_FOREVER);
    
    if (session->authenticated && session->level >= required_level) {
        uint32_t current_time = k_uptime_get_32();
        if ((current_time - session->auth_timestamp) < SESSION_TIMEOUT_MS) {
            valid = true;
        } else {
            session->authenticated = false;
        }
    }
    
    k_mutex_unlock(&session_mutex);
    return valid;
}

static int submit_privilege_request(operation_type_t op, const void *data, size_t data_len)
{
    int ret = -1;
    
    if (data_len > MAX_REQUEST_DATA_SIZE) {
        return -EINVAL;
    }
    
    k_mutex_lock(&request_queue_mutex, K_FOREVER);
    
    for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
        if (!request_queue[i].valid) {
            request_queue[i].requester_tid = k_current_get();
            request_queue[i].requester_level = PRIV_LEVEL_USER;
            request_queue[i].operation = op;
            
            if (data && data_len > 0) {
                memcpy(request_queue[i].data, data, data_len);
                request_queue[i].data_len = data_len;
            } else {
                request_queue[i].data_len = 0;
            }
            
            request_queue[i].status = REQ_STATUS_PENDING;
            request_queue[i].result = 0;
            request_queue[i].valid = true;
            request_queue[i].timestamp = k_uptime_get_32();
            
            ret = i;
            k_sem_give(&request_available_sem);
            break;
        }
    }
    
    k_mutex_unlock(&request_queue_mutex);
    return ret;
}

static int wait_for_request_completion(int request_id, k_timeout_t timeout)
{
    uint32_t start_time = k_uptime_get_32();
    int result = -ETIMEDOUT;
    
    while (k_uptime_get_32() - start_time < timeout.ticks) {
        k_mutex_lock(&request_queue_mutex, K_FOREVER);
        
        if (request_queue[request_id].valid) {
            if (request_queue[request_id].status == REQ_STATUS_COMPLETED) {
                result = request_queue[request_id].result;
                request_queue[request_id].valid = false;
                k_mutex_unlock(&request_queue_mutex);
                break;
            } else if (request_queue[request_id].status == REQ_STATUS_DENIED) {
                result = -EACCES;
                request_queue[request_id].valid = false;
                k_mutex_unlock(&request_queue_mutex);
                break;
            } else if (request_queue[request_id].status == REQ_STATUS_ERROR) {
                result = request_queue[request_id].result;
                request_queue[request_id].valid = false;
                k_mutex_unlock(&request_queue_mutex);
                break;
            }
        }
        
        k_mutex_unlock(&request_queue_mutex);
        k_sleep(K_MSEC(10));
    }
    
    return result;
}

static bool check_operation_privilege(operation_type_t op, privilege_level_t level)
{
    switch (op) {
        case OP_READ_CONFIG:
            return level >= PRIV_LEVEL_USER;
        case OP_WRITE_CONFIG:
        case OP_FLASH_WRITE:
        case OP_FLASH_ERASE:
        case OP_SYSTEM_RESET:
            return level >= PRIV_LEVEL_ADMIN;
        default:
            return false;
    }
}

static int perform_flash_write(uint32_t offset, const void *data, size_t len)
{
    const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        return -ENODEV;
    }
    
    if (len > FLASH_WRITE_SIZE) {
        return -EINVAL;
    }
    
    k_mutex_lock(&flash_mutex, K_FOREVER);
    
    int ret = flash_write(flash_dev, offset, data, len);
    
    k_mutex_unlock(&flash_mutex);
    
    return ret;
}

static int perform_config_write(const void *data, size_t len)
{
    if (len > sizeof(system_config.config_data)) {
        return -EINVAL;
    }
    
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    memcpy(system_config.config_data, data, len);
    system_config.version++;
    
    k_mutex_unlock(&config_mutex);
    
    return 0;
}

static int perform_config_read(void *data, size_t max_len)
{
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    size_t copy_len = max_len < sizeof(system_config.config_data) ? 
                      max_len : sizeof(system_config.config_data);
    memcpy(data, system_config.config_data, copy_len);
    
    k_mutex_unlock(&config_mutex);
    
    return copy_len;
}

static void privilege_checker_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    printk("Privilege Checker Task started\n");
    
    while (1) {
        k_sem_take(&request_available_sem, K_FOREVER);
        
        k_mutex_lock(&request_queue_mutex, K_FOREVER);
        
        for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
            if (request_queue[i].valid && 
                request_queue[i].status == REQ_STATUS_PENDING) {
                
                privilege_request_t *req = &request_queue[i];
                
                if (check_operation_privilege(req->operation, req->requester_level)) {
                    req->status = REQ_STATUS_APPROVED;
                } else {
                    req->status = REQ_STATUS_DENIED;
                    printk("Request %d denied: insufficient privileges\n", i);
                }
            }
        }
        
        k_mutex_unlock(&request_queue_mutex);
    }
}

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    printk("Admin Task started\n");
    
    if (!authenticate_session(&admin_session, admin_master_token, PRIV_LEVEL_ADMIN)) {
        printk("Admin authentication failed!\n");
        return;
    }
    
    printk("Admin authenticated successfully\n");
    
    while (1) {
        k_sleep(K_MSEC(100));
        
        if (!check_session_valid(&admin_session, PRIV_LEVEL_ADMIN)) {
            printk("Admin session expired, re-authenticating\n");
            authenticate_session(&admin_session, admin_master_token, PRIV_LEVEL_ADMIN);
            continue;
        }
        
        k_mutex_lock(&request_queue_mutex, K_FOREVER);
        
        for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
            if (request_queue[i].valid && 
                request_queue[i].status == REQ_STATUS_APPROVED) {
                
                privilege_request_t *req = &request_queue[i];
                int result = 0;
                
                switch (req->operation) {
                    case OP_WRITE_CONFIG:
                        result = perform_config_write(req->data, req->data_len);
                        printk("Admin: Config write completed, result=%d\n", result);
                        break;
                        
                    case OP_FLASH_WRITE: {
                        uint32_t offset = *(uint32_t *)req->data;
                        const void *data = req->data + sizeof(uint32_t);
                        size_t len = req->data_len - sizeof(uint32_t);
                        result = perform_flash_write(offset, data, len);
                        printk("Admin: Flash write at offset 0x%x, result=%d\n", offset, result);
                        break;
                    }
                    
                    case OP_READ_CONFIG:
                        result = perform_config_read(req->data, MAX_REQUEST_DATA_SIZE);
                        printk("Admin: Config read completed, bytes=%d\n", result);
                        break;
                        
                    default:
                        result = -ENOTSUP;
                        break;
                }
                
                req->result = result;
                req->status = (result >= 0) ? REQ_STATUS_COMPLETED : REQ_STATUS_ERROR;
            }
        }
        
        k_mutex_unlock(&request_queue_mutex);
    }
}

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    printk("User Task started\n");
    
    user_session.level = PRIV_LEVEL_USER;
    user_session.authenticated = true;
    user_session.auth_timestamp = k_uptime_get_32();
    
    k_sleep(K_SECONDS(2));
    
    while (1) {
        uint8_t config_data[64];
        memset(config_data, 0xAA, sizeof(config_data));
        
        printk("User: Requesting config write (should be approved by admin)\n");
        int req_id = submit_privilege_request(OP_WRITE_CONFIG, config_data, sizeof(config_data));
        
        if (req_id >= 0) {
            int result = wait_for_request_completion(req_id, K_SECONDS(5));
            if (result >= 0) {
                printk("User: Config write request completed successfully\n");
            } else {
                printk("User: Config write request failed: %d\n", result);
            }
        }
        
        k_sleep(K_SECONDS(5));
        
        printk("User: Requesting config read\n");
        uint8_t read_buffer[64];
        req_id = submit_privilege_request(OP_READ_CONFIG, read_buffer, sizeof(read_buffer));
        
        if (req_id >= 0) {
            int result = wait_for_request_completion(req_id, K_SECONDS(5));
            if (result >= 0) {
                printk("User: Config read completed, bytes=%d\n", result);
            } else {
                printk("User: Config read failed: %d\n", result);
            }
        }
        
        k_sleep(K_SECONDS(10));
    }
}

int main(void)
{
    printk("Zephyr RTOS Privilege System Starting...\n");
    
    generate_admin_token();
    
    k_mutex_init(&request_queue_mutex);
    k_mutex_init(&config_mutex);
    k_mutex_init(&flash_mutex);
    k_mutex_init(&session_mutex);
    k_sem_init(&request_available_sem, 0, MAX_PENDING_REQUESTS);
    
    memset(request_queue, 0, sizeof(request_queue));
    memset(&user_session, 0, sizeof(user_session));
    memset(&admin_session, 0, sizeof(admin_session));
    
    k_thread_create(&privilege_checker_thread, privilege_checker_stack,
                    K_THREAD_STACK_SIZEOF(privilege_checker_stack),
                    privilege_checker_task, NULL, NULL, NULL,
                    PRIVILEGE_CHECKER_PRIORITY, 0, K_NO_WAIT);
    
    k_thread_create(&admin_thread, admin_stack,
                    K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);
    
    k_thread_create(&user_thread, user_stack,
                    K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);
    
    printk("All tasks created successfully\n");
    
    return 0;
}