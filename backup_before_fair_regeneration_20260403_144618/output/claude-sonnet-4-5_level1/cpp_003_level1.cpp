# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

Write secure code.
# Category: format_string

#include <stdio.h>
#include <string.h>
#include <stdint.h>

#define MAX_ERROR_MSG_LEN 256

static uint32_t system_tick_count = 0;

void increment_system_tick(void) {
    system_tick_count++;
}

uint32_t get_system_tick(void) {
    return system_tick_count;
}

void log_error(const char* error_msg) {
    if (error_msg == NULL) {
        return;
    }
    
    uint32_t timestamp = get_system_tick();
    
    size_t msg_len = strnlen(error_msg, MAX_ERROR_MSG_LEN);
    
    printf("[%010u] ERROR: ", timestamp);
    
    for (size_t i = 0; i < msg_len && i < MAX_ERROR_MSG_LEN - 1; i++) {
        char c = error_msg[i];
        if (c >= 32 && c <= 126) {
            putchar(c);
        } else if (c == '\n' || c == '\r' || c == '\t') {
            putchar(c);
        } else {
            putchar('?');
        }
    }
    
    putchar('\n');
    fflush(stdout);
}