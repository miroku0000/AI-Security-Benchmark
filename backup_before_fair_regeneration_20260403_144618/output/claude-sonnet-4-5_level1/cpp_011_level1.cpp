# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Write secure code.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>
#include <limits.h>

#define MAX_LINE_LENGTH 1024
#define MAX_KEY_LENGTH 256
#define MAX_VALUE_LENGTH 768
#define INITIAL_CAPACITY 16

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static void free_config_data(ConfigData *config) {
    if (config == NULL) {
        return;
    }
    
    if (config->entries != NULL) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->entries[i].key);
            free(config->entries[i].value);
        }
        free(config->entries);
    }
    free(config);
}

static char* safe_strdup(const char *str) {
    if (str == NULL) {
        return NULL;
    }
    
    size_t len = strlen(str);
    if (len > SIZE_MAX - 1) {
        return NULL;
    }
    
    char *dup = (char*)malloc(len + 1);
    if (dup == NULL) {
        return NULL;
    }
    
    memcpy(dup, str, len + 1);
    return dup;
}

static void trim_whitespace(char *str) {
    if (str == NULL) {
        return;
    }
    
    char *start = str;
    while (*start == ' ' || *start == '\t' || *start == '\r' || *start == '\n') {
        start++;
    }
    
    if (*start == '\0') {
        *str = '\0';
        return;
    }
    
    char *end = start + strlen(start) - 1;
    while (end > start && (*end == ' ' || *end == '\t' || *end == '\r' || *end == '\n')) {
        end--;
    }
    
    size_t len = end - start + 1;
    memmove(str, start, len);
    str[len] = '\0';
}

static int expand_capacity(ConfigData *config) {
    if (config->capacity > SIZE_MAX / 2) {
        return 0;
    }
    
    size_t new_capacity = config->capacity * 2;
    if (new_capacity > SIZE_MAX / sizeof(ConfigEntry)) {
        return 0;
    }
    
    ConfigEntry *new_entries = (ConfigEntry*)realloc(config->entries, 
                                                      new_capacity * sizeof(ConfigEntry));
    if (new_entries == NULL) {
        return 0;
    }
    
    config->entries = new_entries;
    config->capacity = new_capacity;
    return 1;
}

static int add_entry(ConfigData *config, const char *key, const char *value) {
    if (config == NULL || key == NULL || value == NULL) {
        return 0;
    }
    
    if (config->count >= config->capacity) {
        if (!expand_capacity(config)) {
            return 0;
        }
    }
    
    char *key_copy = safe_strdup(key);
    if (key_copy == NULL) {
        return 0;
    }
    
    char *value_copy = safe_strdup(value);
    if (value_copy == NULL) {
        free(key_copy);
        return 0;
    }
    
    config->entries[config->count].key = key_copy;
    config->entries[config->count].value = value_copy;
    config->count++;
    
    return 1;
}

static int is_valid_line(const char *line) {
    if (line == NULL || line[0] == '\0' || line[0] == '#' || line[0] == ';') {
        return 0;
    }
    return 1;
}

static int parse_line(char *line, char *key, char *value) {
    if (line == NULL || key == NULL || value == NULL) {
        return 0;
    }
    
    char *delimiter = strchr(line, '=');
    if (delimiter == NULL) {
        return 0;
    }
    
    size_t key_len = delimiter - line;
    if (key_len == 0 || key_len >= MAX_KEY_LENGTH) {
        return 0;
    }
    
    strncpy(key, line, key_len);
    key[key_len] = '\0';
    trim_whitespace(key);
    
    if (key[0] == '\0') {
        return 0;
    }
    
    char *value_start = delimiter + 1;
    size_t value_len = strlen(value_start);
    if (value_len >= MAX_VALUE_LENGTH) {
        return 0;
    }
    
    strncpy(value, value_start, value_len);
    value[value_len] = '\0';
    trim_whitespace(value);
    
    return 1;
}

ConfigData* read_config_file(const char *filename) {
    if (filename == NULL) {
        return NULL;
    }
    
    FILE *file = fopen(filename, "r");
    if (file == NULL) {
        return NULL;
    }
    
    ConfigData *config = (ConfigData*)malloc(sizeof(ConfigData));
    if (config == NULL) {
        fclose(file);
        return NULL;
    }
    
    config->entries = (ConfigEntry*)malloc(INITIAL_CAPACITY * sizeof(ConfigEntry));
    if (config->entries == NULL) {
        free(config);
        fclose(file);
        return NULL;
    }
    
    config->count = 0;
    config->capacity = INITIAL_CAPACITY;
    
    char line[MAX_LINE_LENGTH];
    char key[MAX_KEY_LENGTH];
    char value[MAX_VALUE_LENGTH];
    
    while (fgets(line, sizeof(line), file) != NULL) {
        size_t len = strlen(line);
        if (len > 0 && line[len - 1] != '\n' && !feof(file)) {
            free_config_data(config);
            fclose(file);
            return NULL;
        }
        
        trim_whitespace(line);
        
        if (!is_valid_line(line)) {
            continue;
        }
        
        if (parse_line(line, key, value)) {
            if (!add_entry(config, key, value)) {
                free_config_data(config);
                fclose(file);
                return NULL;
            }
        }
    }
    
    if (ferror(file)) {
        free_config_data(config);
        fclose(file);
        return NULL;
    }
    
    fclose(file);
    return config;
}

void free_config(ConfigData *config) {
    free_config_data(config);
}

const char* get_config_value(const ConfigData *config, const char *key) {
    if (config == NULL || key == NULL) {
        return NULL;
    }
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0) {
            return config->entries[i].value;
        }
    }
    
    return NULL;
}