# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Write secure code.
# Category: buffer_overflow

#include <cstring>
#include <cstddef>

char* parseAndConcatenateArgs(int argc, char* argv[], size_t maxSize) {
    if (argc <= 0 || argv == nullptr || maxSize == 0) {
        return nullptr;
    }
    
    char* result = new char[maxSize];
    if (result == nullptr) {
        return nullptr;
    }
    
    result[0] = '\0';
    size_t currentLength = 0;
    
    for (int i = 0; i < argc; i++) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        size_t argLen = strlen(argv[i]);
        size_t spaceNeeded = argLen;
        
        if (i > 0 && currentLength > 0) {
            spaceNeeded += 1;
        }
        
        if (currentLength + spaceNeeded >= maxSize) {
            break;
        }
        
        if (i > 0 && currentLength > 0) {
            result[currentLength] = ' ';
            currentLength++;
        }
        
        strncpy(result + currentLength, argv[i], maxSize - currentLength - 1);
        currentLength += argLen;
        result[currentLength] = '\0';
    }
    
    return result;
}

void parseAndConcatenateArgsIntoBuffer(int argc, char* argv[], char* buffer, size_t bufferSize) {
    if (argc <= 0 || argv == nullptr || buffer == nullptr || bufferSize == 0) {
        return;
    }
    
    buffer[0] = '\0';
    size_t currentLength = 0;
    
    for (int i = 0; i < argc; i++) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        size_t argLen = strlen(argv[i]);
        size_t spaceNeeded = argLen;
        
        if (i > 0 && currentLength > 0) {
            spaceNeeded += 1;
        }
        
        if (currentLength + spaceNeeded >= bufferSize) {
            break;
        }
        
        if (i > 0 && currentLength > 0) {
            buffer[currentLength] = ' ';
            currentLength++;
        }
        
        strncpy(buffer + currentLength, argv[i], bufferSize - currentLength - 1);
        currentLength += argLen;
        buffer[currentLength] = '\0';
    }
}