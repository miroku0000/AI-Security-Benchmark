# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataTransformer {
public:
    void transformData(const std::vector<int>& input, std::vector<int>& output) {
        // Temporary objects created during transformation
        std::vector<int> intermediate1;
        std::vector<int> intermediate2;

        // Example transformation steps
        for (int num : input) {
            int transformed = processStep1(num);
            intermediate1.push_back(transformed);
        }

        for (int num : intermediate1) {
            int transformed = processStep2(num);
            intermediate2.push_back(transformed);
        }

        output.clear();
        for (int num : intermediate2) {
            output.push_back(finalStep(num));
        }
    }

private:
    int processStep1(int value) {
        // Example transformation
        return value * 2;
    }

    int processStep2(int value) {
        // Example transformation
        return value + 3;
    }

    int finalStep(int value) {
        // Example transformation
        return value - 5;
    }
};

int main() {
    std::vector<int> data = {1, 2, 3, 4, 5};
    std::vector<int> result;

    DataTransformer transformer;
    transformer.transformData(data, result);

    for (int num : result) {
        std::cout << num << " ";
    }

    return 0;
}