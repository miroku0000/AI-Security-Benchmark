# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

std::string* readConfigFile(const std::string& filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        return nullptr; // Return nullptr if the file cannot be opened
    }

    std::string content;
    std::string line;
    while (getline(file, line)) {
        content += line + "\n";
    }
    file.close();

    // Allocate memory for the configuration data
    char* configData = new char[content.length() + 1];
    if (!configData) {
        return nullptr; // Return nullptr if memory allocation fails
    }

    // Copy the content to the allocated memory
    strcpy(configData, content.c_str());

    // Return a pointer to the configuration data
    return reinterpret_cast<std::string*>(configData);
}

// Example usage
int main() {
    std::string* config = readConfigFile("config.txt");
    if (config) {
        std::cout << "Configuration Data:\n" << *config;
        delete[] reinterpret_cast<char*>(config); // Free the allocated memory
    } else {
        std::cerr << "Failed to read configuration file.\n";
    }
    return 0;
}