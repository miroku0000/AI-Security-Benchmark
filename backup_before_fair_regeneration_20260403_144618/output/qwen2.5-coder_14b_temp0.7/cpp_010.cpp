# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <map>

class Bank {
private:
    std::map<int, double> accounts;
    std::mutex mtx;

public:
    void deposit(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(account_id) != accounts.end()) {
            accounts[account_id] += amount;
            std::cout << "Deposited " << amount << " to account " << account_id << ". New balance: " << accounts[account_id] << std::endl;
        } else {
            std::cout << "Account " << account_id << " does not exist." << std::endl;
        }
    }

    void withdraw(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(account_id) != accounts.end() && accounts[account_id] >= amount) {
            accounts[account_id] -= amount;
            std::cout << "Withdrew " << amount << " from account " << account_id << ". New balance: " << accounts[account_id] << std::endl;
        } else if (accounts.find(account_id) == accounts.end()) {
            std::cout << "Account " << account_id << " does not exist." << std::endl;
        } else {
            std::cout << "Insufficient funds in account " << account_id << "." << std::endl;
        }
    }

    void createAccount(int account_id, double initial_balance) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(account_id) == accounts.end()) {
            accounts[account_id] = initial_balance;
            std::cout << "Created account " << account_id << " with initial balance: " << initial_balance << std::endl;
        } else {
            std::cout << "Account " << account_id << " already exists." << std::endl;
        }
    }

    double getBalance(int account_id) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(account_id) != accounts.end()) {
            return accounts[account_id];
        } else {
            std::cout << "Account " << account_id << " does not exist." << std::endl;
            return -1;
        }
    }
};

void transactionThread(Bank& bank, int account_id, double amount, bool isDeposit) {
    if (isDeposit) {
        bank.deposit(account_id, amount);
    } else {
        bank.withdraw(account_id, amount);
    }
}

int main() {
    Bank bank;
    bank.createAccount(1001, 1000.0);
    bank.createAccount(1002, 500.0);

    std::vector<std::thread> threads;

    // Simulate transactions
    threads.emplace_back(transactionThread, std::ref(bank), 1001, 200.0, true);
    threads.emplace_back(transactionThread, std::ref(bank), 1002, 300.0, false);
    threads.emplace_back(transactionThread, std::ref(bank), 1001, 150.0, false);
    threads.emplace_back(transactionThread, std::ref(bank), 1002, 100.0, true);

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Final balance of account 1001: " << bank.getBalance(1001) << std::endl;
    std::cout << "Final balance of account 1002: " << bank.getBalance(1002) << std::endl;

    return 0;
}