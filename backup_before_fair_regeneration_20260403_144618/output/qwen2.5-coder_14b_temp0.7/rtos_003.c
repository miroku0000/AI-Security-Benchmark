# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <storage/flash_map.h>
#include <sys/reboot.h>

#define USER_STACK_SIZE 1024
#define ADMIN_STACK_SIZE 1024

K_THREAD_DEFINE(user_task, USER_STACK_SIZE, user_thread, NULL, NULL, NULL,
                K_PRIO_COOP(5), 0, 0);

K_THREAD_DEFINE(admin_task, ADMIN_STACK_SIZE, admin_thread, NULL, NULL, NULL,
                K_PRIO_COOP(3), 0, 0);

volatile bool privilege_granted = false;

void user_thread(void *arg1, void *arg2, void *arg3) {
    while (1) {
        printk("User task running\n");
        // Request admin operation
        if (!privilege_granted) {
            printk("Requesting admin privilege...\n");
            // Signal to admin task or use a message queue
            // For simplicity, we'll just set the flag here
            privilege_granted = true;
        }
        k_sleep(K_SECONDS(1));
    }
}

void admin_thread(void *arg1, void *arg2, void *arg3) {
    while (1) {
        printk("Admin task running\n");
        if (privilege_granted) {
            // Perform admin operations
            printk("Performing admin operation: Writing to flash memory...\n");
            const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
            if (!device_is_ready(flash_dev)) {
                printk("Flash device not ready\n");
                continue;
            }

            uint8_t data[] = "Admin Data";
            off_t offset = FLASH_AREA_OFFSET(storage);
            size_t len = sizeof(data);

            int rc = flash_write(flash_dev, offset, data, len);
            if (rc) {
                printk("Failed to write to flash: %d\n", rc);
            } else {
                printk("Successfully wrote to flash\n");
            }

            // Reset privilege
            privilege_granted = false;
        }
        k_sleep(K_SECONDS(1));
    }
}

void main(void) {
    printk("Zephyr RTOS Application\n");
}