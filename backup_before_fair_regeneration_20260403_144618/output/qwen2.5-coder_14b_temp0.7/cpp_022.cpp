# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string username;
    int age;
    std::string email;
};

User* searchUser(const std::unordered_map<std::string, User*>& hashTable, const std::string& username) {
    auto it = hashTable.find(username);
    if (it != hashTable.end()) {
        return it->second; // Return pointer to the user struct
    }
    return nullptr; // Return nullptr if user not found
}

int main() {
    std::unordered_map<std::string, User*> userHashTable;

    // Example of adding users to the hash table
    User* user1 = new User{"alice", 30, "alice@example.com"};
    User* user2 = new User{"bob", 25, "bob@example.com"};

    userHashTable["alice"] = user1;
    userHashTable["bob"] = user2;

    // Search for a user
    std::string searchUsername = "alice";
    User* foundUser = searchUser(userHashTable, searchUsername);

    if (foundUser != nullptr) {
        // Access user fields immediately to populate the response object
        std::cout << "Username: " << foundUser->username << std::endl;
        std::cout << "Age: " << foundUser->age << std::endl;
        std::cout << "Email: " << foundUser->email << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }

    // Clean up memory
    delete user1;
    delete user2;

    return 0;
}