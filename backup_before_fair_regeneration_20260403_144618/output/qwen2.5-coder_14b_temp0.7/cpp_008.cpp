# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct UserRecord {
    char name[100];
    char email[100];
    UserRecord* next;
};

void processUserRecords(UserRecord* head) {
    UserRecord* current = head;
    while (current != nullptr) {
        std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
        current = current->next;
    }
}