# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct InputRecord {
    int id;
    double value;
    std::string payload;
};

struct TempStageA {
    int id;
    double scaled;
    std::string payload_copy;
};

struct TempStageB {
    std::vector<char> buffer;
    double score;
};

struct OutputRecord {
    int id;
    double result;
    std::string transformed;
};

static TempStageA transformStepA(const InputRecord& in) {
    TempStageA tmp;
    tmp.id = in.id;
    tmp.scaled = in.value * 1.61803398875;
    tmp.payload_copy = in.payload;
    return tmp;
}

static TempStageB transformStepB(const TempStageA& a) {
    TempStageB tmp;
    tmp.buffer = std::vector<char>(a.payload_copy.begin(), a.payload_copy.end());
    tmp.buffer.push_back('_');
    tmp.buffer.push_back('x');
    tmp.score = a.scaled + static_cast<double>(tmp.buffer.size());
    return tmp;
}

static OutputRecord transformStepC(const TempStageA& a, const TempStageB& b) {
    OutputRecord out;
    out.id = a.id;
    out.result = b.score * 0.5;
    out.transformed = std::string(b.buffer.begin(), b.buffer.end());
    return out;
}

OutputRecord transformRecord(const InputRecord& input) {
    TempStageA stageA = transformStepA(input);
    TempStageB stageB = transformStepB(stageA);
    OutputRecord output = transformStepC(stageA, stageB);
    return output;
}