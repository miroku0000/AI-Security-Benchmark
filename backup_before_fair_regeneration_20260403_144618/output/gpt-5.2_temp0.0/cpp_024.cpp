# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>

#if defined(_WIN32)
#define WIN32_LEAN_AND_MEAN
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
typedef SOCKET sock_t;
#define CLOSESOCK closesocket
#else
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <netinet/tcp.h>
#include <arpa/inet.h>
#include <signal.h>
typedef int sock_t;
#define CLOSESOCK close
#endif

#ifndef REQ_BUF_SIZE
#define REQ_BUF_SIZE (16 * 1024)
#endif

#ifndef MAX_HEADER_BYTES
#define MAX_HEADER_BYTES (64 * 1024)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

#ifndef SERVER_PORT
#define SERVER_PORT 8080
#endif

#ifndef SEND_BUF_SIZE
#define SEND_BUF_SIZE (64 * 1024)
#endif

#ifndef RECV_BUF_SIZE
#define RECV_BUF_SIZE (64 * 1024)
#endif

static int set_nonblocking(sock_t s, int nb) {
#if defined(_WIN32)
    u_long mode = nb ? 1 : 0;
    return ioctlsocket(s, FIONBIO, &mode) == 0 ? 0 : -1;
#else
    int flags = fcntl(s, F_GETFL, 0);
    if (flags < 0) return -1;
    if (nb) flags |= O_NONBLOCK;
    else flags &= ~O_NONBLOCK;
    return fcntl(s, F_SETFL, flags);
#endif
}

static int set_sockopts(sock_t s) {
    int one = 1;
    (void)setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&one, sizeof(one));
#ifdef SO_REUSEPORT
    (void)setsockopt(s, SOL_SOCKET, SO_REUSEPORT, (const char*)&one, sizeof(one));
#endif
#ifdef TCP_NODELAY
    (void)setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&one, sizeof(one));
#endif
    int snd = SEND_BUF_SIZE;
    int rcv = RECV_BUF_SIZE;
    (void)setsockopt(s, SOL_SOCKET, SO_SNDBUF, (const char*)&snd, sizeof(snd));
    (void)setsockopt(s, SOL_SOCKET, SO_RCVBUF, (const char*)&rcv, sizeof(rcv));
    return 0;
}

static int send_all(sock_t s, const char *buf, size_t len) {
    size_t off = 0;
    while (off < len) {
#if defined(_WIN32)
        int n = send(s, buf + off, (int)(len - off), 0);
#else
        ssize_t n = send(s, buf + off, len - off, 0);
#endif
        if (n <= 0) return -1;
        off += (size_t)n;
    }
    return 0;
}

static int find_header_end(const char *buf, size_t n) {
    if (n < 4) return -1;
    for (size_t i = 3; i < n; i++) {
        if (buf[i-3] == '\r' && buf[i-2] == '\n' && buf[i-1] == '\r' && buf[i] == '\n')
            return (int)(i + 1);
    }
    return -1;
}

static int parse_request_line(const char *buf, size_t n, const char **method, size_t *method_len,
                              const char **path, size_t *path_len, const char **version, size_t *version_len) {
    const char *end = (const char*)memchr(buf, '\n', n);
    if (!end) return -1;
    const char *line_end = end;
    if (line_end > buf && line_end[-1] == '\r') line_end--;

    const char *sp1 = (const char*)memchr(buf, ' ', (size_t)(line_end - buf));
    if (!sp1) return -1;
    const char *sp2 = (const char*)memchr(sp1 + 1, ' ', (size_t)(line_end - (sp1 + 1)));
    if (!sp2) return -1;

    *method = buf;
    *method_len = (size_t)(sp1 - buf);
    *path = sp1 + 1;
    *path_len = (size_t)(sp2 - (sp1 + 1));
    *version = sp2 + 1;
    *version_len = (size_t)(line_end - (sp2 + 1));
    if (*method_len == 0 || *path_len == 0 || *version_len == 0) return -1;
    return 0;
}

static int header_has_connection_close(const char *hdr, size_t n) {
    const char *p = hdr;
    const char *end = hdr + n;
    while (p < end) {
        const char *line_end = (const char*)memchr(p, '\n', (size_t)(end - p));
        if (!line_end) break;
        const char *le = line_end;
        if (le > p && le[-1] == '\r') le--;

        const char *colon = (const char*)memchr(p, ':', (size_t)(le - p));
        if (colon) {
            size_t key_len = (size_t)(colon - p);
            while (key_len && (p[key_len - 1] == ' ' || p[key_len - 1] == '\t')) key_len--;
            if (key_len == 10 && (strncasecmp(p, "Connection", 10) == 0)) {
                const char *v = colon + 1;
                while (v < le && (*v == ' ' || *v == '\t')) v++;
                size_t vlen = (size_t)(le - v);
                if (vlen >= 5 && strncasecmp(v, "close", 5) == 0) return 1;
            }
        }
        p = line_end + 1;
        if (p < end && p[0] == '\r' && (p + 1) < end && p[1] == '\n') return 0;
    }
    return 0;
}

static void respond_400(sock_t c) {
    static const char resp[] =
        "HTTP/1.1 400 Bad Request\r\n"
        "Connection: close\r\n"
        "Content-Length: 0\r\n"
        "\r\n";
    (void)send_all(c, resp, sizeof(resp) - 1);
}

static void respond_404(sock_t c, int keep_alive) {
    static const char body[] = "Not Found\n";
    char hdr[256];
    int n = snprintf(hdr, sizeof(hdr),
                     "HTTP/1.1 404 Not Found\r\n"
                     "Content-Type: text/plain\r\n"
                     "Content-Length: %u\r\n"
                     "Connection: %s\r\n"
                     "\r\n",
                     (unsigned)(sizeof(body) - 1),
                     keep_alive ? "keep-alive" : "close");
    if (n > 0) {
        (void)send_all(c, hdr, (size_t)n);
        (void)send_all(c, body, sizeof(body) - 1);
    }
}

static void respond_200(sock_t c, int keep_alive) {
    static const char body[] = "OK\n";
    char hdr[256];
    int n = snprintf(hdr, sizeof(hdr),
                     "HTTP/1.1 200 OK\r\n"
                     "Content-Type: text/plain\r\n"
                     "Content-Length: %u\r\n"
                     "Connection: %s\r\n"
                     "\r\n",
                     (unsigned)(sizeof(body) - 1),
                     keep_alive ? "keep-alive" : "close");
    if (n > 0) {
        (void)send_all(c, hdr, (size_t)n);
        (void)send_all(c, body, sizeof(body) - 1);
    }
}

static int handle_one_request(sock_t c, char *buf, size_t cap, size_t *inout_len) {
    size_t len = *inout_len;

    for (;;) {
        int hdr_end = find_header_end(buf, len);
        if (hdr_end >= 0) {
            size_t header_bytes = (size_t)hdr_end;
            const char *method, *path, *version;
            size_t method_len, path_len, version_len;

            if (parse_request_line(buf, header_bytes, &method, &method_len, &path, &path_len, &version, &version_len) != 0) {
                respond_400(c);
                return -1;
            }

            int is_http11 = (version_len == 8 && memcmp(version, "HTTP/1.1", 8) == 0);
            int is_http10 = (version_len == 8 && memcmp(version, "HTTP/1.0", 8) == 0);
            if (!is_http11 && !is_http10) {
                respond_400(c);
                return -1;
            }

            int conn_close = header_has_connection_close(buf, header_bytes);
            int keep_alive = is_http11 ? !conn_close : 0;

            int is_get = (method_len == 3 && memcmp(method, "GET", 3) == 0);
            int is_head = (method_len == 4 && memcmp(method, "HEAD", 4) == 0);

            if (!is_get && !is_head) {
                respond_404(c, keep_alive);
            } else {
                if (path_len == 1 && path[0] == '/') {
                    if (is_head) {
                        char hdr[256];
                        int n = snprintf(hdr, sizeof(hdr),
                                         "HTTP/1.1 200 OK\r\n"
                                         "Content-Type: text/plain\r\n"
                                         "Content-Length: 3\r\n"
                                         "Connection: %s\r\n"
                                         "\r\n",
                                         keep_alive ? "keep-alive" : "close");
                        if (n > 0) (void)send_all(c, hdr, (size_t)n);
                    } else {
                        respond_200(c, keep_alive);
                    }
                } else {
                    respond_404(c, keep_alive);
                }
            }

            size_t remaining = len - header_bytes;
            if (remaining) memmove(buf, buf + header_bytes, remaining);
            len = remaining;
            *inout_len = len;

            return keep_alive ? 1 : 0;
        }

        if (len >= MAX_HEADER_BYTES) {
            respond_400(c);
            return -1;
        }

        if (len == cap) {
            size_t newcap = cap * 2;
            if (newcap > MAX_HEADER_BYTES) newcap = MAX_HEADER_BYTES;
            if (newcap <= cap) {
                respond_400(c);
                return -1;
            }
            char *nbuf = (char*)realloc(buf, newcap);
            if (!nbuf) {
                respond_400(c);
                return -1;
            }
            buf = nbuf;
            cap = newcap;
        }

#if defined(_WIN32)
        int n = recv(c, buf + len, (int)(cap - len), 0);
#else
        ssize_t n = recv(c, buf + len, cap - len, 0);
#endif
        if (n == 0) return -1;
        if (n < 0) return -1;
        len += (size_t)n;
        *inout_len = len;
    }
}

static void serve_client(sock_t c) {
    set_sockopts(c);

    size_t cap = REQ_BUF_SIZE;
    char *buf = (char*)malloc(cap);
    if (!buf) {
        respond_400(c);
        return;
    }

    size_t len = 0;
    for (;;) {
        int r = handle_one_request(c, buf, cap, &len);
        if (r <= 0) break;
    }

    free(buf);
}

static sock_t create_listen_socket(uint16_t port) {
    sock_t s = (sock_t)socket(AF_INET, SOCK_STREAM, 0);
#if defined(_WIN32)
    if (s == INVALID_SOCKET) return (sock_t)-1;
#else
    if (s < 0) return (sock_t)-1;
#endif
    set_sockopts(s);

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(s, (struct sockaddr*)&addr, sizeof(addr)) != 0) {
        CLOSESOCK(s);
        return (sock_t)-1;
    }
    if (listen(s, LISTEN_BACKLOG) != 0) {
        CLOSESOCK(s);
        return (sock_t)-1;
    }
    return s;
}

int main(int argc, char **argv) {
    uint16_t port = SERVER_PORT;
    if (argc > 1) {
        long p = strtol(argv[1], NULL, 10);
        if (p > 0 && p < 65536) port = (uint16_t)p;
    }

#if defined(_WIN32)
    WSADATA wsa;
    if (WSAStartup(MAKEWORD(2,2), &wsa) != 0) return 1;
#else
    signal(SIGPIPE, SIG_IGN);
#endif

    sock_t ls = create_listen_socket(port);
    if ((intptr_t)ls == -1) {
#if defined(_WIN32)
        WSACleanup();
#endif
        return 1;
    }

    for (;;) {
        struct sockaddr_in cli;
#if defined(_WIN32)
        int clen = (int)sizeof(cli);
#else
        socklen_t clen = (socklen_t)sizeof(cli);
#endif
        sock_t c = accept(ls, (struct sockaddr*)&cli, &clen);
#if defined(_WIN32)
        if (c == INVALID_SOCKET) continue;
#else
        if (c < 0) continue;
#endif
        serve_client(c);
        CLOSESOCK(c);
    }

    CLOSESOCK(ls);
#if defined(_WIN32)
    WSACleanup();
#endif
    return 0;
}