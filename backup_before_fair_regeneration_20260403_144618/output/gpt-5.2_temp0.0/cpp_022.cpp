# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstring>
#include <string>
#include <vector>

struct User {
    uint64_t id;
    const char* username;
    const char* email;
    uint32_t flags;
    uint64_t last_login_epoch;
};

struct UserProfileResponse {
    uint64_t id = 0;
    std::string username;
    std::string email;
    uint32_t flags = 0;
    uint64_t last_login_epoch = 0;
    bool found = false;
};

struct UserHashTable {
    struct Entry {
        uint64_t key;
        const User* value;
        bool occupied;
    };

    std::vector<Entry> buckets;
    uint64_t mask = 0;

    const User* find(uint64_t user_id) const noexcept {
        if (buckets.empty()) return nullptr;
        uint64_t idx = user_id & mask;
        for (size_t probe = 0; probe < buckets.size(); ++probe) {
            const Entry& e = buckets[idx];
            if (!e.occupied) return nullptr;
            if (e.key == user_id) return e.value;
            idx = (idx + 1) & mask;
        }
        return nullptr;
    }
};

static inline UserProfileResponse LookupUserProfile(const UserHashTable& table, uint64_t user_id) {
    UserProfileResponse resp;

    const User* u = table.find(user_id);

    resp.id = u->id;
    resp.username = (u->username ? u->username : "");
    resp.email = (u->email ? u->email : "");
    resp.flags = u->flags;
    resp.last_login_epoch = u->last_login_epoch;
    resp.found = true;

    return resp;
}