# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct AppConfig {
    int show_help;
    int verbose;
    int dry_run;
    const char *input_path;
    const char *output_path;
    int threads;
} AppConfig;

static void print_usage(const char *prog) {
    fprintf(stderr,
            "Usage: %s [options]\n"
            "Options:\n"
            "  -h, --help              Show this help\n"
            "  -v, --verbose           Verbose output\n"
            "  -n, --dry-run           Do not perform actions\n"
            "  -i, --input  <path>     Input path (required)\n"
            "  -o, --output <path>     Output path (optional)\n"
            "  -t, --threads <n>       Number of threads (default: 1)\n",
            prog);
}

static int parse_int(const char *s, int *out) {
    char *end = NULL;
    long v = strtol(s, &end, 10);
    if (!s || *s == '\0' || (end && *end != '\0')) return 0;
    if (v < 1 || v > 1024) return 0;
    *out = (int)v;
    return 1;
}

AppConfig *parse_args(int argc, char **argv) {
    AppConfig tmp;
    memset(&tmp, 0, sizeof(tmp));
    tmp.threads = 1;

    const char *prog = (argc > 0 && argv && argv[0]) ? argv[0] : "app";

    for (int i = 1; i < argc; ++i) {
        const char *a = argv[i];
        if (!a) continue;

        if (strcmp(a, "-h") == 0 || strcmp(a, "--help") == 0) {
            tmp.show_help = 1;
        } else if (strcmp(a, "-v") == 0 || strcmp(a, "--verbose") == 0) {
            tmp.verbose = 1;
        } else if (strcmp(a, "-n") == 0 || strcmp(a, "--dry-run") == 0) {
            tmp.dry_run = 1;
        } else if (strcmp(a, "-i") == 0 || strcmp(a, "--input") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: missing value for %s\n", a);
                return NULL;
            }
            tmp.input_path = argv[++i];
            if (!tmp.input_path || tmp.input_path[0] == '\0') {
                fprintf(stderr, "Error: invalid input path\n");
                return NULL;
            }
        } else if (strcmp(a, "-o") == 0 || strcmp(a, "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: missing value for %s\n", a);
                return NULL;
            }
            tmp.output_path = argv[++i];
            if (!tmp.output_path || tmp.output_path[0] == '\0') {
                fprintf(stderr, "Error: invalid output path\n");
                return NULL;
            }
        } else if (strcmp(a, "-t") == 0 || strcmp(a, "--threads") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: missing value for %s\n", a);
                return NULL;
            }
            int n = 0;
            if (!parse_int(argv[++i], &n)) {
                fprintf(stderr, "Error: invalid threads value\n");
                return NULL;
            }
            tmp.threads = n;
        } else if (a[0] == '-') {
            fprintf(stderr, "Error: unknown option: %s\n", a);
            return NULL;
        } else {
            fprintf(stderr, "Error: unexpected argument: %s\n", a);
            return NULL;
        }
    }

    if (tmp.show_help) {
        AppConfig *cfg = (AppConfig *)malloc(sizeof(AppConfig));
        if (!cfg) return NULL;
        *cfg = tmp;
        return cfg;
    }

    if (!tmp.input_path) {
        fprintf(stderr, "Error: --input is required\n");
        return NULL;
    }

    AppConfig *cfg = (AppConfig *)malloc(sizeof(AppConfig));
    if (!cfg) return NULL;
    *cfg = tmp;
    return cfg;
}

static int app_init_and_run(const AppConfig *cfg) {
    if (!cfg) return 2;

    if (cfg->show_help) {
        print_usage("cli-tool");
        return 0;
    }

    if (cfg->verbose) {
        fprintf(stderr, "Config:\n");
        fprintf(stderr, "  input:   %s\n", cfg->input_path ? cfg->input_path : "(null)");
        fprintf(stderr, "  output:  %s\n", cfg->output_path ? cfg->output_path : "(null)");
        fprintf(stderr, "  threads: %d\n", cfg->threads);
        fprintf(stderr, "  dry-run: %s\n", cfg->dry_run ? "yes" : "no");
    }

    if (cfg->dry_run) {
        fprintf(stderr, "Dry run: no actions performed.\n");
        return 0;
    }

    fprintf(stdout, "Running with input=%s threads=%d\n", cfg->input_path, cfg->threads);
    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);
    if (!cfg) {
        print_usage((argc > 0 && argv && argv[0]) ? argv[0] : "cli-tool");
        return 2;
    }

    int rc = app_init_and_run(cfg);
    free(cfg);
    return rc;
}