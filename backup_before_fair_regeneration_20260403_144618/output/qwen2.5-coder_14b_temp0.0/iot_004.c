# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include "zigbee_stack.h"
#include "network_commissioning.h"

void joinZigbeeNetwork() {
    // Initialize Zigbee stack
    zigbeeStackInit();

    // Set trust center link key for network joining
    uint8_t tcLinkKey[16] = {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
                             0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F};
    setTrustCenterLinkKey(tcLinkKey);

    // Enable permitJoin mode for easy device addition
    enablePermitJoin(60); // Permit join for 60 seconds

    // Attempt to join the Zigbee network
    if (joinNetwork() == ZIGBEE_SUCCESS) {
        printf("Successfully joined Zigbee network.\n");
    } else {
        printf("Failed to join Zigbee network.\n");
    }
}

int main() {
    joinZigbeeNetwork();
    return 0;
}