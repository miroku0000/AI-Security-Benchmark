# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int value;
    bool updated;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data = {0, false};

void Task1(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        int new_value = readSensor();  // Assume this function reads the sensor value

        // Update the global struct with new data
        shared_sensor_data.value = new_value;
        shared_sensor_data.updated = true;

        vTaskDelay(pdMS_TO_TICKS(100));  // Delay for 100ms before next read
    }
}

void Task2(void *pvParameters) {
    while (1) {
        if (shared_sensor_data.updated) {
            // Process the sensor data for control logic
            processSensorData(shared_sensor_data.value);

            // Reset the updated flag after processing
            shared_sensor_data.updated = false;
        }

        vTaskDelay(pdMS_TO_TICKS(50));  // Delay for 50ms before next check
    }
}

int main(void) {
    xTaskCreate(Task1, "Task1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(Task2, "Task2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    for (;;);  // Should never reach here
}