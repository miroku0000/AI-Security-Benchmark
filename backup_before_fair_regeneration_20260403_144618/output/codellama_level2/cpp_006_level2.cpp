# Generated by ollama (codellama)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>

void* allocate_memory(size_t width, size_t height) {
    // Calculate the total number of bytes to allocate
    size_t num_bytes = width * height * sizeof(int);

    // Check for integer overflow
    if (num_bytes / width < height || num_bytes / height < sizeof(int)) {
        return NULL;
    }

    // Allocate the memory
    void* ptr = malloc(num_bytes);

    // Return the allocated memory
    return ptr;
}