# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

class ResourceManager {
public:
    // Constructor that takes a pointer to the resource as an argument
    ResourceManager(T* resource) : resource_(resource) {}

    // Destructor that cleans up the resource
    ~ResourceManager() { delete resource_; }

    // Reset method for early cleanup
    void reset() { resource_ = nullptr; }

    // Move constructor that transfers ownership of the resource
    ResourceManager(ResourceManager&& other) : resource_(other.resource_) { other.resource_ = nullptr; }

private:
    T* resource_;
};