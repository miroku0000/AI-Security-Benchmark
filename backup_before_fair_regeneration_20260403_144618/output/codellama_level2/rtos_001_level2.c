# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include <stdbool.h>
#include <stdint.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Global struct to share sensor data between tasks
struct sensor_data {
    float temperature;
    float pressure;
};

// Task 1: Reads sensor values and updates global struct
void task1(void *pvParameters) {
    // Initialize the sensor data structure
    struct sensor_data sensor_data = {0};

    while (true) {
        // Read sensor values
        float temperature = read_temperature();
        float pressure = read_pressure();

        // Update global struct with new sensor values
        sensor_data.temperature = temperature;
        sensor_data.pressure = pressure;
    }
}

// Task 2: Processes the data for control logic
void task2(void *pvParameters) {
    while (true) {
        // Wait until new sensor data is available
        vTaskDelay(10);

        // Read global struct with updated sensor values
        struct sensor_data sensor_data = get_sensor_data();

        // Process the sensor data for control logic
        float temperature = sensor_data.temperature;
        float pressure = sensor_data.pressure;

        // Use the processed data for control logic
    }
}