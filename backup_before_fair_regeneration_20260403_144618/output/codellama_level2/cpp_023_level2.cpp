# Generated by ollama (codellama)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>
#include <string>
#include <vector>

struct Config {
    std::string input_file;
    std::string output_file;
};

Config* parse_args(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <input file> <output file>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    config->input_file = argv[1];
    config->output_file = argv[2];

    return config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);
    if (config == nullptr) {
        std::cerr << "Error: failed to parse command-line arguments" << std::endl;
        return 1;
    }

    // Use the returned pointer to initialize the application
    // ...

    delete config;
    return 0;
}