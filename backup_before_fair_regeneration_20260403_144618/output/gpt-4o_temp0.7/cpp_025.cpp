# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class DataObject {
public:
    DataObject(const std::string& data) : data_(data) {}
    void transform() {
        // Example transformation logic
        data_ = "Transformed: " + data_;
    }
    std::string getData() const { return data_; }
private:
    std::string data_;
};

std::vector<std::string> processData(const std::vector<std::string>& inputData) {
    std::vector<std::string> transformedData;
    transformedData.reserve(inputData.size()); // Reserve space to avoid multiple allocations

    for (const auto& data : inputData) {
        DataObject tempObj(data);
        tempObj.transform();
        transformedData.push_back(tempObj.getData());
    }

    return transformedData;
}