# Generated by openai (gpt-4o)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

#define MAX_SESSIONS 100
#define SESSION_TIMEOUT 3600

typedef struct {
    char session_id[64];
    char *data;
    time_t last_accessed;
    int is_valid;
} Session;

Session cache[MAX_SESSIONS];

void init_cache() {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache[i].session_id[0] = '\0';
        cache[i].data = NULL;
        cache[i].last_accessed = 0;
        cache[i].is_valid = 0;
    }
}

int find_session_index(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (strcmp(cache[i].session_id, session_id) == 0) {
            return i;
        }
    }
    return -1;
}

char *create_session(const char *session_id, const char *data) {
    int index = find_session_index(session_id);
    if (index == -1) {
        for (int i = 0; i < MAX_SESSIONS; i++) {
            if (cache[i].session_id[0] == '\0') {
                strcpy(cache[i].session_id, session_id);
                cache[i].data = strdup(data);
                cache[i].last_accessed = time(NULL);
                cache[i].is_valid = 1;
                return cache[i].session_id;
            }
        }
        return NULL;
    } else {
        if (!cache[index].is_valid) {
            cache[index].data = strdup(data);
            cache[index].last_accessed = time(NULL);
            cache[index].is_valid = 1;
            return cache[index].session_id;
        }
        return NULL;
    }
}

char *access_session(const char *session_id) {
    int index = find_session_index(session_id);
    if (index != -1 && cache[index].is_valid) {
        if (difftime(time(NULL), cache[index].last_accessed) < SESSION_TIMEOUT) {
            cache[index].last_accessed = time(NULL);
            return cache[index].data;
        } else {
            free(cache[index].data);
            cache[index].data = NULL;
            cache[index].is_valid = 0;
        }
    }
    return NULL;
}

void invalidate_session(const char *session_id) {
    int index = find_session_index(session_id);
    if (index != -1) {
        free(cache[index].data);
        cache[index].data = NULL;
        cache[index].is_valid = 0;
    }
}

int main() {
    init_cache();

    create_session("session1", "User data for session1");
    char *data = access_session("session1");
    if (data) printf("Accessed session1: %s\n", data);

    invalidate_session("session1");
    data = access_session("session1");
    if (!data) printf("Session session1 invalidated\n");

    return 0;
}