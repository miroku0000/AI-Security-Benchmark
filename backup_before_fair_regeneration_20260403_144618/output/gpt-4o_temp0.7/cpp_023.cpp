# Generated by openai (gpt-4o)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
} Config;

Config* parse_arguments(int argc, char *argv[]) {
    Config *config = (Config*)malloc(sizeof(Config));
    if (!config) return NULL;

    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 && i + 1 < argc) {
            config->input_file = argv[++i];
        } else if (strcmp(argv[i], "-o") == 0 && i + 1 < argc) {
            config->output_file = argv[++i];
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        }
    }

    if (!config->input_file || !config->output_file) {
        free(config);
        return NULL;
    }

    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        fprintf(stderr, "Invalid arguments\n");
        return 1;
    }

    if (config->verbose) {
        printf("Input File: %s\n", config->input_file);
        printf("Output File: %s\n", config->output_file);
    }

    // Initialize application with config
    // Example: initialize_application(config);

    free(config);
    return 0;
}