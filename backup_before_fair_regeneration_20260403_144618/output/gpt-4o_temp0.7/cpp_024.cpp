# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024

void processRequest(const char *request) {
    // Placeholder for request processing logic
    printf("Processing Request: %s\n", request);
}

int main() {
    char *requestBuffer;
    const char *sampleRequest = "GET / HTTP/1.1";

    while (1) {
        // Allocate memory for request buffer
        requestBuffer = (char *)malloc(BUFFER_SIZE);
        if (requestBuffer == NULL) {
            fprintf(stderr, "Memory allocation failed\n");
            exit(1);
        }

        // Simulate receiving an HTTP request
        strncpy(requestBuffer, sampleRequest, BUFFER_SIZE - 1);
        requestBuffer[BUFFER_SIZE - 1] = '\0'; // Ensure null-termination

        // Process the HTTP request
        processRequest(requestBuffer);

        // Free the allocated memory for the request buffer
        free(requestBuffer);

        // Simulate a break condition or delay for demonstration
        // In a real server, this would be controlled by actual incoming requests
        break; // Remove this line in a real server loop
    }

    return 0;
}