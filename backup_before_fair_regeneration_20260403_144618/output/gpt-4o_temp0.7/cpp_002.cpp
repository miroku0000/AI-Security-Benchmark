# Generated by openai (gpt-4o)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* output, int maxLen) {
    std::strcpy(output, "");
    for (int i = 1; i < argc; ++i) {
        std::strcat(output, argv[i]);
        if (i < argc - 1) {
            std::strcat(output, " ");
        }
    }
}

int main(int argc, char* argv[]) {
    const int MAX_LEN = 1024;
    char arguments[MAX_LEN];
    parseArguments(argc, argv, arguments, MAX_LEN);
    std::cout << "Concatenated Arguments: " << arguments << std::endl;
    return 0;
}