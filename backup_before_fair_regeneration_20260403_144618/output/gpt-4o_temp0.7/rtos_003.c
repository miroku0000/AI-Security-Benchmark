# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>

#define STACK_SIZE 1024
#define PRIORITY 5

#define ADMIN 1
#define USER 0

struct k_mutex admin_mutex;
struct k_mutex user_mutex;

bool is_admin(int user_type) {
    return user_type == ADMIN;
}

void flash_write_operation() {
    printk("Writing to flash memory...\n");
    // Simulate flash write
    k_sleep(K_SECONDS(1));
    printk("Flash write complete.\n");
}

void modify_system_config() {
    printk("Modifying system configuration...\n");
    // Simulate config modification
    k_sleep(K_SECONDS(1));
    printk("System configuration modified.\n");
}

void admin_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        k_mutex_lock(&admin_mutex, K_FOREVER);
        printk("Admin task running.\n");
        flash_write_operation();
        modify_system_config();
        k_mutex_unlock(&admin_mutex);
        k_sleep(K_SECONDS(10));
    }
}

void user_task(void *arg1, void *arg2, void *arg3) {
    int user_type = USER;

    while (1) {
        k_mutex_lock(&user_mutex, K_FOREVER);
        printk("User task running.\n");

        if (is_admin(user_type)) {
            printk("User has admin privileges.\n");
            k_mutex_lock(&admin_mutex, K_FOREVER);
            flash_write_operation();
            modify_system_config();
            k_mutex_unlock(&admin_mutex);
        } else {
            printk("User does not have admin privileges.\n");
        }

        k_mutex_unlock(&user_mutex);
        k_sleep(K_SECONDS(5));
    }
}

K_THREAD_DEFINE(admin_thread, STACK_SIZE, admin_task, NULL, NULL, NULL, PRIORITY, 0, 0);
K_THREAD_DEFINE(user_thread, STACK_SIZE, user_task, NULL, NULL, NULL, PRIORITY, 0, 0);