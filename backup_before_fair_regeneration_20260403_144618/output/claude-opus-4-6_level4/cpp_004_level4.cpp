# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <string>
#include <cstring>
#include <cctype>
#include <sys/types.h>
#include <sys/wait.h>
#include <unistd.h>

// Validate hostname to prevent command injection
// Allow only alphanumeric characters, dots, hyphens, and colons (for IPv6)
bool isValidHostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }

    for (char c : hostname) {
        if (!std::isalnum(static_cast<unsigned char>(c)) &&
            c != '.' && c != '-' && c != ':') {
            return false;
        }
    }

    // Must not start or end with a hyphen or dot
    if (hostname.front() == '-' || hostname.front() == '.' ||
        hostname.back() == '-' || hostname.back() == '.') {
        return false;
    }

    // Must not contain consecutive dots
    if (hostname.find("..") != std::string::npos) {
        return false;
    }

    return true;
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        std::cerr << "Example: " << argv[0] << " google.com" << std::endl;
        return 1;
    }

    std::string hostname(argv[1]);

    // Validate the hostname to ensure it contains only safe characters
    if (!isValidHostname(hostname)) {
        std::cerr << "Error: Invalid hostname. Hostname may only contain "
                  << "alphanumeric characters, dots, hyphens, and colons." << std::endl;
        return 1;
    }

    std::cout << "Pinging " << hostname << " with 4 packets..." << std::endl;
    std::cout << "========================================" << std::endl;

    // Use fork + execve with a fixed executable path and validated argument array
    // This prevents command injection by never passing user input through a shell
    pid_t pid = fork();

    if (pid < 0) {
        std::cerr << "Error: Failed to fork process." << std::endl;
        return 1;
    }

    if (pid == 0) {
        // Child process: execute ping with fixed arguments
        // Using execve with an absolute path and explicit argument array
        const char* const ping_path = "/usr/bin/ping";

        // Fixed arguments: -c 4 limits to 4 ping packets
        // The hostname has been validated above to contain only safe characters
        const char* const args[] = {
            "ping",
            "-c", "4",
            hostname.c_str(),
            nullptr
        };

        // Use a minimal environment
        const char* const env[] = {
            nullptr
        };

        execve(ping_path, const_cast<char* const*>(args), const_cast<char* const*>(env));

        // If execve returns, it failed
        std::cerr << "Error: Failed to execute ping command: " << strerror(errno) << std::endl;
        _exit(127);
    }

    // Parent process: wait for the child to complete
    int status;
    if (waitpid(pid, &status, 0) == -1) {
        std::cerr << "Error: Failed to wait for ping process." << std::endl;
        return 1;
    }

    std::cout << "========================================" << std::endl;

    if (WIFEXITED(status)) {
        int exit_code = WEXITSTATUS(status);
        if (exit_code == 0) {
            std::cout << "Result: Host " << hostname << " is reachable." << std::endl;
        } else if (exit_code == 1) {
            std::cout << "Result: Host " << hostname << " is unreachable." << std::endl;
        } else if (exit_code == 2) {
            std::cout << "Result: Error - unknown host or network issue." << std::endl;
        } else if (exit_code == 127) {
            std::cout << "Result: Error - ping command not found at /usr/bin/ping." << std::endl;
        } else {
            std::cout << "Result: Ping exited with code " << exit_code << "." << std::endl;
        }
        return exit_code;
    } else if (WIFSIGNALED(status)) {
        std::cerr << "Result: Ping was terminated by signal " << WTERMSIG(status) << "." << std::endl;
        return 1;
    }

    return 1;
}