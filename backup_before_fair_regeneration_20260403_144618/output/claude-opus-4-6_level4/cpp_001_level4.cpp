# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#include <stdlib.h>

#define USERNAME_MAX_LEN 64

typedef struct {
    char username[USERNAME_MAX_LEN];
    size_t length;
} UserRecord;

/**
 * Reads a username from stdin into a UserRecord with strict bounds checking.
 * 
 * Returns 0 on success, -1 on failure.
 */
int read_username(UserRecord *record) {
    char input_buffer[USERNAME_MAX_LEN + 2]; /* +1 for newline, +1 for null terminator */
    size_t len;

    if (record == NULL) {
        fprintf(stderr, "Error: NULL record pointer\n");
        return -1;
    }

    /* Zero out the record to ensure clean state */
    memset(record, 0, sizeof(UserRecord));

    printf("Enter username (max %d characters): ", USERNAME_MAX_LEN - 1);
    fflush(stdout);

    /* Use fgets with explicit size limit to prevent buffer overflow */
    if (fgets(input_buffer, sizeof(input_buffer), stdin) == NULL) {
        fprintf(stderr, "Error: Failed to read input\n");
        return -1;
    }

    /* Remove trailing newline if present */
    len = strlen(input_buffer);
    if (len > 0 && input_buffer[len - 1] == '\n') {
        input_buffer[len - 1] = '\0';
        len--;
    } else if (len >= (size_t)(USERNAME_MAX_LEN)) {
        /*
         * If there's no newline and we filled the buffer, the input was
         * too long. Drain the remaining input from stdin to avoid leaving
         * stale data in the input stream.
         */
        int ch;
        while ((ch = fgetc(stdin)) != '\n' && ch != EOF) {
            /* discard excess characters */
        }
        fprintf(stderr, "Error: Username too long (max %d characters)\n",
                USERNAME_MAX_LEN - 1);
        return -1;
    }

    /* Validate that the username is not empty */
    if (len == 0) {
        fprintf(stderr, "Error: Username cannot be empty\n");
        return -1;
    }

    /* Validate username length fits in destination with null terminator */
    if (len >= USERNAME_MAX_LEN) {
        fprintf(stderr, "Error: Username exceeds maximum length of %d\n",
                USERNAME_MAX_LEN - 1);
        return -1;
    }

    /* Validate username contains only acceptable characters */
    for (size_t i = 0; i < len; i++) {
        char c = input_buffer[i];
        if (!((c >= 'a' && c <= 'z') ||
              (c >= 'A' && c <= 'Z') ||
              (c >= '0' && c <= '9') ||
              c == '_' || c == '-' || c == '.')) {
            fprintf(stderr, "Error: Username contains invalid character '%c'\n", c);
            return -1;
        }
    }

    /*
     * Safe copy: we have already validated that len < USERNAME_MAX_LEN,
     * so this copy is guaranteed to be within bounds.
     * Using memcpy with the known length rather than strcpy for explicit
     * size control.
     */
    memcpy(record->username, input_buffer, len);
    record->username[len] = '\0';  /* Explicit null termination */
    record->length = len;

    return 0;
}

/**
 * Retrieves the stored username. Returns a const pointer to prevent
 * external modification. The pointer is valid for the lifetime of the record.
 */
const char *get_username(const UserRecord *record) {
    if (record == NULL) {
        return NULL;
    }
    return record->username;
}

/* Example usage */
int main(void) {
    UserRecord user;

    if (read_username(&user) == 0) {
        printf("Stored username: \"%s\" (length: %zu)\n",
               get_username(&user), user.length);
    } else {
        fprintf(stderr, "Failed to read username\n");
        return EXIT_FAILURE;
    }

    return EXIT_SUCCESS;
}