# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <cstdint>
#include <cstddef>
#include <stdexcept>
#include <limits>
#include <algorithm>
#include <functional>

// Represents a data record flowing through the pipeline
struct DataRecord {
    std::vector<uint8_t> payload;
    uint64_t timestamp;
    uint32_t source_id;
    uint32_t flags;
};

// Intermediate transformation result with clear ownership
struct TransformResult {
    std::vector<uint8_t> transformed_data;
    uint64_t checksum;
    bool valid;
};

// Object pool to avoid repeated allocations in the hot path
template <typename T>
class ObjectPool {
public:
    explicit ObjectPool(size_t initial_capacity = 64) {
        if (initial_capacity > max_pool_size_) {
            throw std::invalid_argument("Initial capacity exceeds maximum pool size");
        }
        pool_.reserve(initial_capacity);
        for (size_t i = 0; i < initial_capacity; ++i) {
            pool_.push_back(std::make_unique<T>());
        }
    }

    // Acquire an object from the pool; creates new one if pool is empty
    std::unique_ptr<T> acquire() {
        if (!pool_.empty()) {
            auto obj = std::move(pool_.back());
            pool_.pop_back();
            return obj;
        }
        return std::make_unique<T>();
    }

    // Return an object to the pool for reuse
    void release(std::unique_ptr<T> obj) {
        if (!obj) return;
        if (pool_.size() < max_pool_size_) {
            pool_.push_back(std::move(obj));
        }
        // If pool is full, unique_ptr destructor handles cleanup
    }

    size_t available() const { return pool_.size(); }

private:
    std::vector<std::unique_ptr<T>> pool_;
    static constexpr size_t max_pool_size_ = 4096;
};

// Reusable scratch buffer to minimize allocations
class ScratchBuffer {
public:
    explicit ScratchBuffer(size_t initial_size = 4096) {
        if (initial_size > max_buffer_size_) {
            throw std::invalid_argument("Initial size exceeds maximum buffer size");
        }
        buffer_.resize(initial_size);
    }

    // Ensure buffer has at least `needed` bytes, with overflow check
    void ensure_capacity(size_t needed) {
        if (needed > max_buffer_size_) {
            throw std::length_error("Requested buffer size exceeds safety limit");
        }
        if (buffer_.size() < needed) {
            buffer_.resize(needed);
        }
        used_ = 0;
    }

    uint8_t* data() { return buffer_.data(); }
    const uint8_t* data() const { return buffer_.data(); }
    size_t capacity() const { return buffer_.size(); }
    size_t used() const { return used_; }

    void set_used(size_t n) {
        if (n > buffer_.size()) {
            throw std::out_of_range("Used size exceeds buffer capacity");
        }
        used_ = n;
    }

    // Safe copy into buffer with bounds checking
    void copy_from(const uint8_t* src, size_t src_len, size_t offset = 0) {
        if (!src && src_len > 0) {
            throw std::invalid_argument("Null source with non-zero length");
        }
        if (offset > buffer_.size()) {
            throw std::out_of_range("Offset exceeds buffer capacity");
        }
        // Overflow-safe check: offset + src_len > buffer_.size()
        if (src_len > buffer_.size() - offset) {
            throw std::out_of_range("Copy would exceed buffer capacity");
        }
        std::copy(src, src + src_len, buffer_.begin() + static_cast<ptrdiff_t>(offset));
    }

private:
    std::vector<uint8_t> buffer_;
    size_t used_ = 0;
    static constexpr size_t max_buffer_size_ = 256 * 1024 * 1024; // 256 MB safety limit
};

// Compute a simple checksum (FNV-1a inspired)
static uint64_t compute_checksum(const uint8_t* data, size_t len) {
    if (!data && len > 0) {
        throw std::invalid_argument("Null data with non-zero length");
    }
    uint64_t hash = 0xcbf29ce484222325ULL;
    for (size_t i = 0; i < len; ++i) {
        hash ^= static_cast<uint64_t>(data[i]);
        hash *= 0x100000001b3ULL;
    }
    return hash;
}

// Safe multiplication with overflow check
static size_t safe_multiply(size_t a, size_t b) {
    if (a == 0 || b == 0) return 0;
    if (a > std::numeric_limits<size_t>::max() / b) {
        throw std::overflow_error("Size multiplication overflow");
    }
    return a * b;
}

// Safe addition with overflow check
static size_t safe_add(size_t a, size_t b) {
    if (a > std::numeric_limits<size_t>::max() - b) {
        throw std::overflow_error("Size addition overflow");
    }
    return a + b;
}

// Pipeline transformation context - holds pooled resources to avoid
// per-call allocations in the hot path
class TransformContext {
public:
    TransformContext()
        : result_pool_(128),
          scratch_a_(8192),
          scratch_b_(8192) {}

    // Non-copyable, non-movable to prevent ownership confusion
    TransformContext(const TransformContext&) = delete;
    TransformContext& operator=(const TransformContext&) = delete;
    TransformContext(TransformContext&&) = delete;
    TransformContext& operator=(TransformContext&&) = delete;

    ObjectPool<TransformResult>& result_pool() { return result_pool_; }
    ScratchBuffer& scratch_a() { return scratch_a_; }
    ScratchBuffer& scratch_b() { return scratch_b_; }

private:
    ObjectPool<TransformResult> result_pool_;
    ScratchBuffer scratch_a_;
    ScratchBuffer scratch_b_;
};

// Step 1: Normalize - XOR with source_id pattern, write to scratch_a
static void step_normalize(const DataRecord& record, ScratchBuffer& scratch) {
    size_t payload_size = record.payload.size();
    if (payload_size == 0) {
        scratch.ensure_capacity(0);
        scratch.set_used(0);
        return;
    }

    scratch.ensure_capacity(payload_size);
    scratch.copy_from(record.payload.data(), payload_size);

    uint8_t* buf = scratch.data();
    uint8_t key = static_cast<uint8_t>(record.source_id & 0xFF);
    for (size_t i = 0; i < payload_size; ++i) {
        buf[i] ^= key;
    }
    scratch.set_used(payload_size);
}

// Step 2: Expand - each byte becomes two bytes (byte, complement), write to scratch_b
static void step_expand(ScratchBuffer& input, ScratchBuffer& output) {
    size_t input_len = input.used();
    if (input_len == 0) {
        output.ensure_capacity(0);
        output.set_used(0);
        return;
    }

    size_t output_len = safe_multiply(input_len, 2);
    output.ensure_capacity(output_len);

    const uint8_t* in = input.data();
    uint8_t* out = output.data();
    for (size_t i = 0; i < input_len; ++i) {
        size_t out_idx = i * 2;
        out[out_idx] = in[i];
        out[out_idx + 1] = static_cast<uint8_t>(~in[i]);
    }
    output.set_used(output_len);
}

// Step 3: Compress - take pairs and reduce back, applying flag-based transform
static void step_compress(ScratchBuffer& input, ScratchBuffer& output, uint32_t flags) {
    size_t input_len = input.used();
    if (input_len == 0) {
        output.ensure_capacity(0);
        output.set_used(0);
        return;
    }

    // Output is half the input (round up for odd lengths)
    size_t output_len = (input_len + 1) / 2;
    output.ensure_capacity(output_len);

    const uint8_t* in = input.data();
    uint8_t* out = output.data();
    uint8_t flag_byte = static_cast<uint8_t>(flags & 0xFF);

    for (size_t i = 0; i < output_len; ++i) {
        size_t idx0 = i * 2;
        size_t idx1 = idx0 + 1;
        uint8_t a = in[idx0];
        uint8_t b = (idx1 < input_len) ? in[idx1] : 0;
        out[i] = static_cast<uint8_t>((a + b + flag_byte) & 0xFF);
    }
    output.set_used(output_len);
}

// Main hot-path transformation function
// Takes a DataRecord, returns a TransformResult with clear ownership via unique_ptr
std::unique_ptr<TransformResult> transform_record(
    const DataRecord& record,
    TransformContext& ctx)
{
    // Validate input
    static constexpr size_t max_payload_size = 128 * 1024 * 1024; // 128 MB
    if (record.payload.size() > max_payload_size) {
        throw std::invalid_argument("Payload exceeds maximum allowed size");
    }

    // Acquire a result object from the pool (avoids allocation in steady state)
    auto result = ctx.result_pool().acquire();

    // Step 1: Normalize into scratch_a
    step_normalize(record, ctx.scratch_a());

    // Step 2: Expand from scratch_a into scratch_b
    step_expand(ctx.scratch_a(), ctx.scratch_b());

    // Step 3: Compress from scratch_b back into scratch_a
    step_compress(ctx.scratch_b(), ctx.scratch_a(), record.flags);

    // Finalize result - copy from scratch buffer into result with clear ownership
    size_t final_size = ctx.scratch_a().used();
    result->transformed_data.resize(final_size);
    if (final_size > 0) {
        std::copy(ctx.scratch_a().data(),
                  ctx.scratch_a().data() + final_size,
                  result->transformed_data.begin());
    }

    // Compute checksum over the final transformed data
    result->checksum = (final_size > 0)
        ? compute_checksum(result->transformed_data.data(), final_size)
        : 0;
    result->valid = true;

    return result; // Caller owns the unique_ptr
}

// Batch processing for throughput - processes multiple records,
// reusing the context's pooled resources across calls
std::vector<std::unique_ptr<TransformResult>> transform_batch(
    const std::vector<DataRecord>& records,
    TransformContext& ctx)
{
    if (records.size() > std::numeric_limits<size_t>::max() / sizeof(std::unique_ptr<TransformResult>)) {
        throw std::overflow_error("Batch size would overflow result vector allocation");
    }

    std::vector<std::unique_ptr<TransformResult>> results;
    results.reserve(records.size());

    for (const auto& record : records) {
        try {
            results.push_back(transform_record(record, ctx));
        } catch (const std::exception&) {
            // On failure, create an invalid result rather than losing track of ordering
            auto failed_result = ctx.result_pool().acquire();
            failed_result->transformed_data.clear();
            failed_result->checksum = 0;
            failed_result->valid = false;
            results.push_back(std::move(failed_result));
        }
    }

    return results; // Caller owns all results via unique_ptrs in the vector
}

// Return results to the pool after the caller is done with them
void recycle_results(
    std::vector<std::unique_ptr<TransformResult>>& results,
    TransformContext& ctx)
{
    for (auto& r : results) {
        if (r) {
            // Clear data before returning to pool
            r->transformed_data.clear();
            r->checksum = 0;
            r->valid = false;
            ctx.result_pool().release(std::move(r));
        }
    }
    results.clear();
}

// Example usage / test
#include <iostream>
#include <chrono>

int main() {
    // Create a thread-local or per-thread context for the hot path
    TransformContext ctx;

    // Create sample records
    std::vector<DataRecord> batch;
    batch.reserve(1000);
    for (uint32_t i = 0; i < 1000; ++i) {
        DataRecord rec;
        rec.timestamp = static_cast<uint64_t>(i) * 1000;
        rec.source_id = i % 256;
        rec.flags = i;
        rec.payload.resize(512);
        for (size_t j = 0; j < 512; ++j) {
            rec.payload[j] = static_cast<uint8_t>((i + j) & 0xFF);
        }
        batch.push_back(std::move(rec));
    }

    // Benchmark the hot path
    auto start = std::chrono::high_resolution_clock::now();

    constexpr int iterations = 100;
    for (int iter = 0; iter < iterations; ++iter) {
        auto results = transform_batch(batch, ctx);

        // Verify results
        size_t valid_count = 0;
        for (const auto& r : results) {
            if (r && r->valid) ++valid_count;
        }

        // Recycle results back to pool for next iteration
        recycle_results(results, ctx);
    }

    auto end = std::chrono::high_resolution_clock::now();
    auto elapsed = std::chrono::duration_cast<std::chrono::microseconds>(end - start);

    std::cout << "Processed " << (1000 * iterations) << " records in "
              << elapsed.count() << " microseconds" << std::endl;
    std::cout << "Pool available after run: " << ctx.result_pool().available() << std::endl;

    // Single record test
    DataRecord single;
    single.timestamp = 42;
    single.source_id = 7;
    single.flags = 0xDEAD;
    single.payload = {0x01, 0x02, 0x03, 0x04, 0x05};

    auto single_result = transform_record(single, ctx);
    std::cout << "Single record: valid=" << single_result->valid
              << " size=" << single_result->transformed_data.size()
              << " checksum=0x" << std::hex << single_result->checksum
              << std::dec << std::endl;

    // Ownership is clear: unique_ptr cleans up when it goes out of scope
    return 0;
}