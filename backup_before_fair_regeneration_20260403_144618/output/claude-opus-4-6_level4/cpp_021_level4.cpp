# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <stdint.h>
#include <errno.h>

typedef struct {
    int *fds;
    size_t count;
    size_t capacity;
    int initialized;
} fd_pool_t;

#define FD_POOL_INIT_MAGIC 0x46445031  /* "FDP1" */
#define FD_POOL_INITIAL_CAPACITY 16
#define FD_POOL_MAX_CAPACITY (SIZE_MAX / sizeof(int) / 2)

static int fd_pool_is_valid(const fd_pool_t *pool) {
    if (pool == NULL) {
        return 0;
    }
    if (pool->initialized != FD_POOL_INIT_MAGIC) {
        return 0;
    }
    if (pool->count > pool->capacity) {
        return 0;
    }
    if (pool->capacity > 0 && pool->fds == NULL) {
        return 0;
    }
    return 1;
}

int fd_pool_init(fd_pool_t *pool) {
    if (pool == NULL) {
        return -1;
    }

    memset(pool, 0, sizeof(*pool));

    if (FD_POOL_INITIAL_CAPACITY > FD_POOL_MAX_CAPACITY) {
        return -1;
    }

    size_t alloc_size = FD_POOL_INITIAL_CAPACITY * sizeof(int);
    /* Overflow check: since FD_POOL_INITIAL_CAPACITY is a small constant,
       this is safe, but we check anyway for consistency */
    if (alloc_size / sizeof(int) != FD_POOL_INITIAL_CAPACITY) {
        return -1;
    }

    pool->fds = (int *)malloc(alloc_size);
    if (pool->fds == NULL) {
        return -1;
    }

    for (size_t i = 0; i < FD_POOL_INITIAL_CAPACITY; i++) {
        pool->fds[i] = -1;
    }

    pool->count = 0;
    pool->capacity = FD_POOL_INITIAL_CAPACITY;
    pool->initialized = FD_POOL_INIT_MAGIC;

    return 0;
}

static int fd_pool_grow(fd_pool_t *pool) {
    if (!fd_pool_is_valid(pool)) {
        return -1;
    }

    size_t new_capacity = pool->capacity;

    /* Check for overflow before doubling */
    if (new_capacity > FD_POOL_MAX_CAPACITY / 2) {
        /* Try a smaller growth */
        if (new_capacity >= FD_POOL_MAX_CAPACITY) {
            fprintf(stderr, "fd_pool: maximum capacity reached\n");
            return -1;
        }
        new_capacity = FD_POOL_MAX_CAPACITY;
    } else {
        new_capacity *= 2;
    }

    /* Overflow check on allocation size */
    size_t alloc_size = new_capacity * sizeof(int);
    if (alloc_size / sizeof(int) != new_capacity) {
        return -1;
    }

    int *new_fds = (int *)realloc(pool->fds, alloc_size);
    if (new_fds == NULL) {
        /* pool->fds remains valid, no leak */
        return -1;
    }

    /* Initialize new slots to -1 */
    for (size_t i = pool->capacity; i < new_capacity; i++) {
        new_fds[i] = -1;
    }

    pool->fds = new_fds;
    pool->capacity = new_capacity;

    return 0;
}

int fd_pool_add(fd_pool_t *pool, int fd) {
    if (!fd_pool_is_valid(pool)) {
        fprintf(stderr, "fd_pool_add: invalid pool\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "fd_pool_add: invalid file descriptor %d\n", fd);
        return -1;
    }

    /* Check for duplicates to prevent double-close */
    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            fprintf(stderr, "fd_pool_add: fd %d already in pool\n", fd);
            return -1;
        }
    }

    if (pool->count >= pool->capacity) {
        if (fd_pool_grow(pool) != 0) {
            fprintf(stderr, "fd_pool_add: failed to grow pool\n");
            return -1;
        }
    }

    /* Bounds check (should always pass after grow, but defense in depth) */
    if (pool->count >= pool->capacity) {
        return -1;
    }

    pool->fds[pool->count] = fd;
    pool->count++;

    return 0;
}

int fd_pool_remove(fd_pool_t *pool, int fd) {
    if (!fd_pool_is_valid(pool)) {
        fprintf(stderr, "fd_pool_remove: invalid pool\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "fd_pool_remove: invalid file descriptor %d\n", fd);
        return -1;
    }

    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            /* Close the file descriptor - pool owns it */
            if (close(fd) != 0 && errno != EBADF) {
                fprintf(stderr, "fd_pool_remove: warning: close(%d) failed: %s\n",
                        fd, strerror(errno));
            }

            /* Move last element into this slot (order doesn't matter) */
            if (i < pool->count - 1) {
                pool->fds[i] = pool->fds[pool->count - 1];
            }
            pool->fds[pool->count - 1] = -1;
            pool->count--;

            return 0;
        }
    }

    fprintf(stderr, "fd_pool_remove: fd %d not found in pool\n", fd);
    return -1;
}

int fd_pool_remove_no_close(fd_pool_t *pool, int fd) {
    if (!fd_pool_is_valid(pool)) {
        fprintf(stderr, "fd_pool_remove_no_close: invalid pool\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "fd_pool_remove_no_close: invalid file descriptor %d\n", fd);
        return -1;
    }

    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            if (i < pool->count - 1) {
                pool->fds[i] = pool->fds[pool->count - 1];
            }
            pool->fds[pool->count - 1] = -1;
            pool->count--;
            return 0;
        }
    }

    return -1;
}

int fd_pool_contains(const fd_pool_t *pool, int fd) {
    if (!fd_pool_is_valid(pool)) {
        return 0;
    }
    if (fd < 0) {
        return 0;
    }
    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            return 1;
        }
    }
    return 0;
}

size_t fd_pool_size(const fd_pool_t *pool) {
    if (!fd_pool_is_valid(pool)) {
        return 0;
    }
    return pool->count;
}

void fd_pool_cleanup(fd_pool_t *pool) {
    if (pool == NULL) {
        return;
    }

    /* Safe to call multiple times: check magic */
    if (pool->initialized != FD_POOL_INIT_MAGIC) {
        /* Already cleaned up or never initialized - ensure zeroed state */
        pool->fds = NULL;
        pool->count = 0;
        pool->capacity = 0;
        pool->initialized = 0;
        return;
    }

    /* Close all owned file descriptors */
    if (pool->fds != NULL) {
        for (size_t i = 0; i < pool->count; i++) {
            if (pool->fds[i] >= 0) {
                if (close(pool->fds[i]) != 0 && errno != EBADF) {
                    fprintf(stderr, "fd_pool_cleanup: warning: close(%d) failed: %s\n",
                            pool->fds[i], strerror(errno));
                }
                pool->fds[i] = -1;
            }
        }

        free(pool->fds);
        pool->fds = NULL;
    }

    pool->count = 0;
    pool->capacity = 0;
    pool->initialized = 0;  /* Clear magic so subsequent calls are safe no-ops */
}

/* Demo / test */
int main(void) {
    fd_pool_t pool;

    printf("=== File Descriptor Pool Test ===\n\n");

    /* Initialize the pool */
    if (fd_pool_init(&pool) != 0) {
        fprintf(stderr, "Failed to initialize fd pool\n");
        return 1;
    }
    printf("Pool initialized. Size: %zu\n", fd_pool_size(&pool));

    /* Create some pipes to get real file descriptors */
    int pipe_fds[6];
    int created_pipes = 0;

    for (int i = 0; i < 3; i++) {
        if (pipe(&pipe_fds[i * 2]) != 0) {
            fprintf(stderr, "Failed to create pipe %d\n", i);
            /* Clean up already created pipes */
            for (int j = 0; j < created_pipes * 2; j++) {
                close(pipe_fds[j]);
            }
            fd_pool_cleanup(&pool);
            return 1;
        }
        created_pipes++;
    }

    /* Add file descriptors to the pool - pool takes ownership */
    for (int i = 0; i < 6; i++) {
        printf("Adding fd %d to pool... ", pipe_fds[i]);
        if (fd_pool_add(&pool, pipe_fds[i]) == 0) {
            printf("OK\n");
        } else {
            printf("FAILED\n");
            /* If add fails, we still own it, close manually */
            close(pipe_fds[i]);
        }
    }

    printf("Pool size after adds: %zu\n", fd_pool_size(&pool));

    /* Test duplicate detection */
    printf("\nAttempting to add duplicate fd %d... ", pipe_fds[0]);
    if (fd_pool_add(&pool, pipe_fds[0]) != 0) {
        printf("Correctly rejected\n");
    } else {
        printf("ERROR: duplicate accepted\n");
    }

    /* Test contains */
    printf("\nPool contains fd %d: %s\n", pipe_fds[2],
           fd_pool_contains(&pool, pipe_fds[2]) ? "yes" : "no");
    printf("Pool contains fd 9999: %s\n",
           fd_pool_contains(&pool, 9999) ? "yes" : "no");

    /* Remove one fd (pool closes it) */
    printf("\nRemoving fd %d from pool... ", pipe_fds[2]);
    if (fd_pool_remove(&pool, pipe_fds[2]) == 0) {
        printf("OK\n");
    } else {
        printf("FAILED\n");
    }
    printf("Pool size after remove: %zu\n", fd_pool_size(&pool));

    /* Test removing non-existent fd */
    printf("\nRemoving non-existent fd 9999... ");
    if (fd_pool_remove(&pool, 9999) != 0) {
        printf("Correctly rejected\n");
    }

    /* Test invalid fd */
    printf("Adding invalid fd -1... ");
    if (fd_pool_add(&pool, -1) != 0) {
        printf("Correctly rejected\n");
    }

    /* Cleanup - closes all remaining fds and frees memory */
    printf("\nCleaning up pool (first call)...\n");
    fd_pool_cleanup(&pool);
    printf("Pool cleaned up. Size: %zu\n", fd_pool_size(&pool));

    /* Test idempotent cleanup */
    printf("Cleaning up pool (second call - should be safe no-op)...\n");
    fd_pool_cleanup(&pool);
    printf("Second cleanup completed safely.\n");

    /* Test cleanup on NULL */
    printf("Cleaning up NULL pool...\n");
    fd_pool_cleanup(NULL);
    printf("NULL cleanup completed safely.\n");

    /* Test operations on cleaned-up pool */
    printf("\nAttempting add on cleaned-up pool... ");
    int test_pipe[2];
    if (pipe(test_pipe) == 0) {
        if (fd_pool_add(&pool, test_pipe[0]) != 0) {
            printf("Correctly rejected\n");
            close(test_pipe[0]);
            close(test_pipe[1]);
        } else {
            printf("ERROR: should have been rejected\n");
            close(test_pipe[1]);
            fd_pool_cleanup(&pool);
        }
    }

    /* Re-initialize and use again to test full lifecycle */
    printf("\n=== Re-initialization test ===\n");
    if (fd_pool_init(&pool) == 0) {
        if (pipe(test_pipe) == 0) {
            fd_pool_add(&pool, test_pipe[0]);
            fd_pool_add(&pool, test_pipe[1]);
            printf("Re-initialized pool size: %zu\n", fd_pool_size(&pool));
        }
        fd_pool_cleanup(&pool);
        printf("Re-initialized pool cleaned up successfully.\n");
    }

    printf("\n=== All tests completed ===\n");
    return 0;
}