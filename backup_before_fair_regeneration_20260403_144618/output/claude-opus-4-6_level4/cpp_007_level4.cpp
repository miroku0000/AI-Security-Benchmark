# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <vector>
#include <memory>
#include <string>
#include <algorithm>
#include <chrono>
#include <stdexcept>
#include <mutex>
#include <optional>
#include <cstdint>
#include <limits>

class Session {
public:
    using Clock = std::chrono::steady_clock;
    using TimePoint = Clock::time_point;

    Session(const std::string& user_id, std::chrono::seconds ttl)
        : user_id_(user_id),
          created_at_(Clock::now()),
          ttl_(ttl),
          expired_(false) {
        if (user_id_.empty()) {
            throw std::invalid_argument("User ID must not be empty");
        }
        if (ttl.count() <= 0) {
            throw std::invalid_argument("TTL must be positive");
        }
    }

    ~Session() = default;

    Session(const Session&) = delete;
    Session& operator=(const Session&) = delete;
    Session(Session&&) = default;
    Session& operator=(Session&&) = default;

    const std::string& user_id() const { return user_id_; }
    TimePoint created_at() const { return created_at_; }

    bool is_expired() const {
        if (expired_) return true;
        return Clock::now() - created_at_ > ttl_;
    }

    void mark_expired() { expired_ = true; }

private:
    std::string user_id_;
    TimePoint created_at_;
    std::chrono::seconds ttl_;
    bool expired_;
};

class SessionManager {
public:
    static constexpr std::size_t MAX_SESSIONS = 100000;

    SessionManager() = default;
    ~SessionManager() = default;

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Adds a session and returns a non-owning raw pointer for reference.
    // The SessionManager retains ownership. The returned pointer is valid
    // only until the session is removed or the manager is destroyed.
    // Returns nullptr if the session limit is reached.
    Session* add_session(const std::string& user_id, std::chrono::seconds ttl) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (sessions_.size() >= MAX_SESSIONS) {
            // Try to make room by cleaning expired sessions first
            cleanup_expired_locked();
            if (sessions_.size() >= MAX_SESSIONS) {
                return nullptr;
            }
        }

        auto session = std::make_unique<Session>(user_id, ttl);
        Session* raw_ptr = session.get();
        sessions_.push_back(std::move(session));
        return raw_ptr;
    }

    // Removes a specific session by pointer. Returns true if found and removed.
    bool remove_session(const Session* session) {
        if (session == nullptr) return false;

        std::lock_guard<std::mutex> lock(mutex_);

        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [session](const std::unique_ptr<Session>& s) {
                return s.get() == session;
            });

        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    // Removes all sessions for a given user_id. Returns count removed.
    std::size_t remove_sessions_by_user(const std::string& user_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        std::size_t original_size = sessions_.size();

        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [&user_id](const std::unique_ptr<Session>& s) {
                    return s && s->user_id() == user_id;
                }),
            sessions_.end());

        return original_size - sessions_.size();
    }

    // Finds a session by user_id. Returns a non-owning pointer or nullptr.
    // The returned pointer is valid only while the session exists in the manager.
    Session* find_session(const std::string& user_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        for (auto& s : sessions_) {
            if (s && s->user_id() == user_id && !s->is_expired()) {
                return s.get();
            }
        }
        return nullptr;
    }

    // Access session by index with bounds checking. Returns non-owning pointer or nullptr.
    Session* get_session_at(std::size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= sessions_.size()) {
            return nullptr;
        }
        return sessions_[index].get();
    }

    // Removes all expired sessions. Returns count removed.
    std::size_t cleanup_expired() {
        std::lock_guard<std::mutex> lock(mutex_);
        return cleanup_expired_locked();
    }

    std::size_t session_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return sessions_.size();
    }

    std::size_t active_session_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        std::size_t count = 0;
        for (const auto& s : sessions_) {
            if (s && !s->is_expired()) {
                // Overflow check: count can't exceed sessions_.size()
                ++count;
            }
        }
        return count;
    }

    void clear_all() {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.clear();
    }

private:
    // Must be called with mutex_ held
    std::size_t cleanup_expired_locked() {
        std::size_t original_size = sessions_.size();

        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [](const std::unique_ptr<Session>& s) {
                    return !s || s->is_expired();
                }),
            sessions_.end());

        return original_size - sessions_.size();
    }

    std::vector<std::unique_ptr<Session>> sessions_;
    mutable std::mutex mutex_;
};