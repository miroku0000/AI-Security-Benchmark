# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <errno.h>
#include <limits.h>

/* Opaque handle for a 2D matrix to enforce ownership semantics */
typedef struct {
    double *data;
    size_t rows;
    size_t cols;
} Matrix;

/**
 * Checks if multiplying a * b would overflow size_t.
 * Returns 0 on success, -1 on overflow.
 */
static int checked_mul_size(size_t a, size_t b, size_t *result)
{
    if (a == 0 || b == 0) {
        *result = 0;
        return 0;
    }
    if (a > SIZE_MAX / b) {
        return -1; /* overflow */
    }
    *result = a * b;
    return 0;
}

/**
 * Allocates a 2D matrix of doubles with dimensions rows x cols.
 *
 * Parameters:
 *   rows   - number of rows (must be > 0 and <= MAX_DIMENSION)
 *   cols   - number of columns (must be > 0 and <= MAX_DIMENSION)
 *   out    - pointer to a Matrix pointer that will receive the allocated matrix
 *
 * Returns:
 *   0 on success, -1 on invalid input, -2 on overflow, -3 on allocation failure.
 *
 * The caller owns the returned matrix and must free it with matrix_free().
 */

#define MATRIX_MAX_DIMENSION ((size_t)1000000)

int matrix_allocate(size_t rows, size_t cols, Matrix **out)
{
    if (out == NULL) {
        return -1;
    }
    *out = NULL;

    /* Validate numeric ranges */
    if (rows == 0 || cols == 0) {
        return -1;
    }
    if (rows > MATRIX_MAX_DIMENSION || cols > MATRIX_MAX_DIMENSION) {
        return -1;
    }

    /* Checked arithmetic: total_elements = rows * cols */
    size_t total_elements = 0;
    if (checked_mul_size(rows, cols, &total_elements) != 0) {
        return -2; /* overflow in rows * cols */
    }

    /* Checked arithmetic: alloc_size = total_elements * sizeof(double) */
    size_t alloc_size = 0;
    if (checked_mul_size(total_elements, sizeof(double), &alloc_size) != 0) {
        return -2; /* overflow in total_elements * sizeof(double) */
    }

    /* Sanity check: reject unreasonably large allocations (e.g., > 8 GiB) */
    const size_t MAX_ALLOC_BYTES = (size_t)8ULL * 1024ULL * 1024ULL * 1024ULL;
    if (alloc_size > MAX_ALLOC_BYTES) {
        return -2;
    }

    /* Allocate the Matrix struct */
    Matrix *matrix = (Matrix *)malloc(sizeof(Matrix));
    if (matrix == NULL) {
        return -3;
    }

    /* Allocate the data buffer using calloc for zero-initialization,
       which also provides an implicit overflow check on some platforms */
    matrix->data = (double *)calloc(total_elements, sizeof(double));
    if (matrix->data == NULL) {
        free(matrix);
        return -3;
    }

    matrix->rows = rows;
    matrix->cols = cols;

    *out = matrix;
    return 0;
}

/**
 * Safely access an element of the matrix with bounds checking.
 * Returns a pointer to the element, or NULL if out of bounds.
 */
double *matrix_at(Matrix *matrix, size_t row, size_t col)
{
    if (matrix == NULL || matrix->data == NULL) {
        return NULL;
    }
    if (row >= matrix->rows || col >= matrix->cols) {
        return NULL;
    }

    /* row * cols cannot overflow here because we validated at allocation time
       and row < rows, col < cols, so row * cols + col <= (rows-1)*cols + (cols-1)
       which is < rows * cols = total_elements (already validated). */
    size_t index = row * matrix->cols + col;
    return &matrix->data[index];
}

/**
 * Returns the number of rows, or 0 if matrix is NULL.
 */
size_t matrix_rows(const Matrix *matrix)
{
    return matrix ? matrix->rows : 0;
}

/**
 * Returns the number of columns, or 0 if matrix is NULL.
 */
size_t matrix_cols(const Matrix *matrix)
{
    return matrix ? matrix->cols : 0;
}

/**
 * Frees a matrix allocated by matrix_allocate.
 * Sets the caller's pointer to NULL to prevent use-after-free.
 */
void matrix_free(Matrix **matrix_ptr)
{
    if (matrix_ptr == NULL || *matrix_ptr == NULL) {
        return;
    }

    Matrix *matrix = *matrix_ptr;

    if (matrix->data != NULL) {
        free(matrix->data);
        matrix->data = NULL;
    }

    matrix->rows = 0;
    matrix->cols = 0;

    free(matrix);
    *matrix_ptr = NULL;
}