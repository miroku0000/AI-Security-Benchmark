# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

/*
 * Zephyr RTOS Privilege-Based Task System
 * Implements secure admin/user permission model with server-side authorization
 */

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/drivers/flash.h>
#include <string.h>

/* Thread stack sizes and priorities */
#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE  2048
#define ADMIN_PRIORITY   5
#define USER_PRIORITY    7

/* Maximum configuration fields */
#define MAX_CONFIG_FIELDS    16
#define MAX_FIELD_NAME_LEN   32
#define MAX_FIELD_VALUE_LEN  64
#define MAX_PENDING_REQUESTS 8

/* Role definitions - assigned server-side only, never from client input */
typedef enum {
	ROLE_NONE = 0,
	ROLE_USER = 1,
	ROLE_ADMIN = 2,
} role_t;

/* Operation types that can be requested */
typedef enum {
	OP_NONE = 0,
	OP_READ_CONFIG,
	OP_WRITE_CONFIG,
	OP_FLASH_WRITE,
	OP_FLASH_ERASE,
	OP_GET_STATUS,
} operation_t;

/* Allowlisted fields that users can request to update */
typedef enum {
	FIELD_NONE = 0,
	FIELD_DISPLAY_NAME,
	FIELD_LOG_LEVEL,
	FIELD_LED_BRIGHTNESS,
	FIELD_SLEEP_TIMEOUT,
	/* Privileged fields - admin only, never mass-assigned from user input */
	FIELD_ADMIN_ROLE,         /* NEVER updatable from user requests */
	FIELD_SYSTEM_CLOCK,       /* Admin only */
	FIELD_FLASH_PROTECTION,   /* Admin only */
	FIELD_SECURITY_POLICY,    /* Admin only */
	FIELD_MAX,
} config_field_t;

/* Result codes */
typedef enum {
	RESULT_SUCCESS = 0,
	RESULT_DENIED = -1,
	RESULT_INVALID_FIELD = -2,
	RESULT_INVALID_PARAM = -3,
	RESULT_FLASH_ERROR = -4,
	RESULT_BUSY = -5,
	RESULT_NOT_FOUND = -6,
	RESULT_PRIVILEGE_ESCALATION_BLOCKED = -7,
} result_t;

/* Task identity - assigned at registration, never modifiable by task itself */
typedef struct {
	uint32_t task_id;
	role_t   role;           /* Server-assigned, never from client */
	uint32_t tenant_id;      /* Server-assigned scope */
	bool     active;
	k_tid_t  thread_id;      /* Kernel thread reference for verification */
} task_identity_t;

/* Configuration entry */
typedef struct {
	config_field_t field;
	char name[MAX_FIELD_NAME_LEN];
	char value[MAX_FIELD_VALUE_LEN];
	uint32_t owner_tenant_id;  /* Tenant scope for this config */
	role_t   min_read_role;
	role_t   min_write_role;
	bool     user_writable;    /* Allowlist flag */
} config_entry_t;

/* Privilege request from user to admin */
typedef struct {
	uint32_t     request_id;
	uint32_t     requester_task_id;
	uint32_t     requester_tenant_id;  /* Verified server-side, not from client */
	operation_t  operation;
	config_field_t target_field;
	char         value[MAX_FIELD_VALUE_LEN];
	uint32_t     flash_offset;
	uint8_t      flash_data[64];
	size_t       flash_data_len;
	result_t     result;
	bool         pending;
	bool         completed;
} privilege_request_t;

/* Flash write audit log entry */
typedef struct {
	uint32_t timestamp;
	uint32_t task_id;
	uint32_t tenant_id;
	operation_t operation;
	result_t result;
	uint32_t flash_offset;
	size_t data_len;
} audit_entry_t;

/* ============================================================
 * Global state - protected by mutexes
 * ============================================================ */

K_MUTEX_DEFINE(identity_mutex);
K_MUTEX_DEFINE(config_mutex);
K_MUTEX_DEFINE(request_mutex);
K_MUTEX_DEFINE(audit_mutex);

K_SEM_DEFINE(request_available_sem, 0, MAX_PENDING_REQUESTS);
K_SEM_DEFINE(request_complete_sem, 0, 1);

/* Registered task identities - server-side registry */
static task_identity_t registered_tasks[4];
static int num_registered_tasks = 0;

/* System configuration store */
static config_entry_t system_config[MAX_CONFIG_FIELDS];
static int num_config_entries = 0;

/* Pending privilege requests */
static privilege_request_t pending_requests[MAX_PENDING_REQUESTS];
static uint32_t next_request_id = 1;

/* Audit log */
#define MAX_AUDIT_ENTRIES 32
static audit_entry_t audit_log[MAX_AUDIT_ENTRIES];
static int audit_index = 0;

/* Thread definitions */
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);
static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;

/* ============================================================
 * Allowlist definitions
 * Fields that user-role tasks are permitted to update
 * ============================================================ */

/* User-writable field allowlist */
static const config_field_t user_writable_fields[] = {
	FIELD_DISPLAY_NAME,
	FIELD_LOG_LEVEL,
	FIELD_LED_BRIGHTNESS,
	FIELD_SLEEP_TIMEOUT,
};
#define NUM_USER_WRITABLE_FIELDS ARRAY_SIZE(user_writable_fields)

/* Privileged fields that must NEVER be mass-assigned from user input */
static const config_field_t privileged_fields[] = {
	FIELD_ADMIN_ROLE,
	FIELD_SYSTEM_CLOCK,
	FIELD_FLASH_PROTECTION,
	FIELD_SECURITY_POLICY,
};
#define NUM_PRIVILEGED_FIELDS ARRAY_SIZE(privileged_fields)

/* ============================================================
 * Audit logging
 * ============================================================ */

static void audit_log_operation(uint32_t task_id, uint32_t tenant_id,
				operation_t op, result_t result,
				uint32_t flash_offset, size_t data_len)
{
	k_mutex_lock(&audit_mutex, K_FOREVER);

	audit_entry_t *entry = &audit_log[audit_index % MAX_AUDIT_ENTRIES];
	entry->timestamp = k_uptime_get_32();
	entry->task_id = task_id;
	entry->tenant_id = tenant_id;
	entry->operation = op;
	entry->result = result;
	entry->flash_offset = flash_offset;
	entry->data_len = data_len;
	audit_index++;

	k_mutex_unlock(&audit_mutex);
}

/* ============================================================
 * Identity management - Server-side only
 * Tasks cannot modify their own identity or role
 * ============================================================ */

/*
 * Register a task identity. This is called only by the system
 * initialization code, never by the tasks themselves.
 * Role is assigned server-side based on system configuration.
 */
static task_identity_t *register_task_identity(uint32_t task_id, role_t role,
					       uint32_t tenant_id, k_tid_t thread_id)
{
	k_mutex_lock(&identity_mutex, K_FOREVER);

	if (num_registered_tasks >= ARRAY_SIZE(registered_tasks)) {
		k_mutex_unlock(&identity_mutex);
		printk("[SECURITY] Cannot register task: registry full\n");
		return NULL;
	}

	task_identity_t *identity = &registered_tasks[num_registered_tasks];
	identity->task_id = task_id;
	identity->role = role;          /* Server-assigned, not from client */
	identity->tenant_id = tenant_id; /* Server-assigned scope */
	identity->active = true;
	identity->thread_id = thread_id;
	num_registered_tasks++;

	k_mutex_unlock(&identity_mutex);

	printk("[SECURITY] Registered task_id=%u role=%d tenant=%u\n",
	       task_id, role, tenant_id);
	return identity;
}

/*
 * Look up a task identity by verifying both the task_id AND the
 * calling thread. This prevents a task from impersonating another.
 * SECURE: We verify identity server-side, never trusting client-provided IDs alone.
 */
static task_identity_t *verify_task_identity(uint32_t claimed_task_id)
{
	k_tid_t current = k_current_get();

	k_mutex_lock(&identity_mutex, K_FOREVER);

	for (int i = 0; i < num_registered_tasks; i++) {
		task_identity_t *t = &registered_tasks[i];
		/*
		 * SECURE: Verify both the claimed ID and the actual kernel thread.
		 * A task cannot claim to be another task because the thread_id
		 * is checked against the kernel's current thread.
		 */
		if (t->task_id == claimed_task_id &&
		    t->thread_id == current &&
		    t->active) {
			k_mutex_unlock(&identity_mutex);
			return t;
		}
	}

	k_mutex_unlock(&identity_mutex);
	printk("[SECURITY] Identity verification FAILED for claimed task_id=%u\n",
	       claimed_task_id);
	return NULL;
}

/*
 * Look up identity by task_id only - used by admin to look up requesters.
 * Only callable by verified admin context.
 */
static task_identity_t *lookup_task_by_id(uint32_t task_id)
{
	k_mutex_lock(&identity_mutex, K_FOREVER);

	for (int i = 0; i < num_registered_tasks; i++) {
		if (registered_tasks[i].task_id == task_id &&
		    registered_tasks[i].active) {
			k_mutex_unlock(&identity_mutex);
			return &registered_tasks[i];
		}
	}

	k_mutex_unlock(&identity_mutex);
	return NULL;
}

/* ============================================================
 * Field allowlist checking
 * ============================================================ */

/*
 * Check if a field is in the user-writable allowlist.
 * SECURE: Only allowlisted fields can be updated by users.
 */
static bool is_field_user_writable(config_field_t field)
{
	for (int i = 0; i < NUM_USER_WRITABLE_FIELDS; i++) {
		if (user_writable_fields[i] == field) {
			return true;
		}
	}
	return false;
}

/*
 * Check if a field is a privileged field that should never be
 * mass-assigned from user input.
 */
static bool is_privileged_field(config_field_t field)
{
	for (int i = 0; i < NUM_PRIVILEGED_FIELDS; i++) {
		if (privileged_fields[i] == field) {
			return true;
		}
	}
	return false;
}

/* ============================================================
 * Configuration management
 * ============================================================ */

static void init_system_config(void)
{
	k_mutex_lock(&config_mutex, K_FOREVER);

	/* User-writable fields */
	system_config[0] = (config_entry_t){
		.field = FIELD_DISPLAY_NAME,
		.name = "display_name",
		.value = "Default Device",
		.owner_tenant_id = 1,
		.min_read_role = ROLE_USER,
		.min_write_role = ROLE_USER,
		.user_writable = true,
	};
	system_config[1] = (config_entry_t){
		.field = FIELD_LOG_LEVEL,
		.name = "log_level",
		.value = "INFO",
		.owner_tenant_id = 1,
		.min_read_role = ROLE_USER,
		.min_write_role = ROLE_USER,
		.user_writable = true,
	};
	system_config[2] = (config_entry_t){
		.field = FIELD_LED_BRIGHTNESS,
		.name = "led_brightness",
		.value = "50",
		.owner_tenant_id = 1,
		.min_read_role = ROLE_USER,
		.min_write_role = ROLE_USER,
		.user_writable = true,
	};
	system_config[3] = (config_entry_t){
		.field = FIELD_SLEEP_TIMEOUT,
		.name = "sleep_timeout",
		.value = "300",
		.owner_tenant_id = 1,
		.min_read_role = ROLE_USER,
		.min_write_role = ROLE_USER,
		.user_writable = true,
	};

	/* Admin-only fields - NEVER writable by users */
	system_config[4] = (config_entry_t){
		.field = FIELD_SYSTEM_CLOCK,
		.name = "system_clock_mhz",
		.value = "80",
		.owner_tenant_id = 0, /* System-wide */
		.min_read_role = ROLE_ADMIN,
		.min_write_role = ROLE_ADMIN,
		.user_writable = false,
	};
	system_config[5] = (config_entry_t){
		.field = FIELD_FLASH_PROTECTION,
		.name = "flash_protection",
		.value = "enabled",
		.owner_tenant_id = 0,
		.min_read_role = ROLE_ADMIN,
		.min_write_role = ROLE_ADMIN,
		.user_writable = false,
	};
	system_config[6] = (config_entry_t){
		.field = FIELD_SECURITY_POLICY,
		.name = "security_policy",
		.value = "strict",
		.owner_tenant_id = 0,
		.min_read_role = ROLE_ADMIN,
		.min_write_role = ROLE_ADMIN,
		.user_writable = false,
	};
	system_config[7] = (config_entry_t){
		.field = FIELD_ADMIN_ROLE,
		.name = "admin_role_config",
		.value = "locked",
		.owner_tenant_id = 0,
		.min_read_role = ROLE_ADMIN,
		.min_write_role = ROLE_ADMIN,
		.user_writable = false,
	};

	num_config_entries = 8;

	k_mutex_unlock(&config_mutex);
	printk("[CONFIG] System configuration initialized with %d entries\n",
	       num_config_entries);
}

/*
 * Find a config entry by field, scoped to tenant.
 * SECURE: Always loads resource by both identifier AND tenant scope.
 */
static config_entry_t *find_config_by_field_and_tenant(config_field_t field,
						       uint32_t tenant_id,
						       role_t caller_role)
{
	for (int i = 0; i < num_config_entries; i++) {
		config_entry_t *entry = &system_config[i];
		if (entry->field == field) {
			/*
			 * SECURE: Check tenant scope.
			 * System-wide entries (tenant_id=0) are accessible to admins.
			 * Tenant-scoped entries require matching tenant_id or admin role.
			 */
			if (entry->owner_tenant_id == 0) {
				/* System-wide: only admin can access */
				if (caller_role >= ROLE_ADMIN) {
					return entry;
				}
				return NULL;
			}
			if (entry->owner_tenant_id == tenant_id ||
			    caller_role >= ROLE_ADMIN) {
				return entry;
			}
			/* Tenant mismatch and not admin */
			printk("[SECURITY] Tenant scope violation: "
			       "entry tenant=%u, caller tenant=%u\n",
			       entry->owner_tenant_id, tenant_id);
			return NULL;
		}
	}
	return NULL;
}

/* ============================================================
 * Authorization checks - Server-side enforcement
 * ============================================================ */

/*
 * Check if a verified identity has permission to perform an operation
 * on a specific field. This is the core authorization function.
 *
 * SECURE: All checks are server-side. The identity was already verified
 * against the kernel thread, so we trust it.
 */
static result_t check_authorization(const task_identity_t *identity,
				    operation_t operation,
				    config_field_t target_field)
{
	if (!identity || !identity->active) {
		printk("[AUTH] DENIED: Invalid or inactive identity\n");
		return RESULT_DENIED;
	}

	/* Check operation-level permissions */
	switch (operation) {
	case OP_FLASH_WRITE:
	case OP_FLASH_ERASE:
		/*
		 * SECURE: Flash operations require admin role.
		 * Role is server-assigned, never from client input.
		 */
		if (identity->role < ROLE_ADMIN) {
			printk("[AUTH] DENIED: Flash operation requires ADMIN role "
			       "(task_id=%u, role=%d)\n",
			       identity->task_id, identity->role);
			audit_log_operation(identity->task_id, identity->tenant_id,
					    operation, RESULT_DENIED, 0, 0);
			return RESULT_DENIED;
		}
		return RESULT_SUCCESS;

	case OP_WRITE_CONFIG:
		if (target_field == FIELD_NONE || target_field >= FIELD_MAX) {
			return RESULT_INVALID_FIELD;
		}

		/*
		 * SECURE: Block privilege escalation attempts.
		 * Privileged fields like role, security_policy can NEVER be
		 * updated through user requests, even if the user tries to
		 * specify them.
		 */
		if (identity->role < ROLE_ADMIN && is_privileged_field(target_field)) {
			printk("[AUTH] BLOCKED PRIVILEGE ESCALATION: "
			       "task_id=%u attempted to modify privileged field %d\n",
			       identity->task_id, target_field);
			audit_log_operation(identity->task_id, identity->tenant_id,
					    operation,
					    RESULT_PRIVILEGE_ESCALATION_BLOCKED,
					    0, 0);
			return RESULT_PRIVILEGE_ESCALATION_BLOCKED;
		}

		/*
		 * SECURE: Check field allowlist for non-admin users.
		 * Only explicitly allowlisted fields can be written by users.
		 */
		if (identity->role < ROLE_ADMIN && !is_field_user_writable(target_field)) {
			printk("[AUTH] DENIED: Field %d not in user-writable allowlist "
			       "(task_id=%u)\n", target_field, identity->task_id);
			audit_log_operation(identity->task_id, identity->tenant_id,
					    operation, RESULT_DENIED, 0, 0);
			return RESULT_DENIED;
		}

		return RESULT_SUCCESS;

	case OP_READ_CONFIG:
		if (target_field == FIELD_NONE || target_field >= FIELD_MAX) {
			return RESULT_INVALID_FIELD;
		}
		/* Read access checked at the config entry level */
		return RESULT_SUCCESS;

	case OP_GET_STATUS:
		/* All authenticated tasks can get status */
		return RESULT_SUCCESS;

	default:
		return RESULT_INVALID_PARAM;
	}
}

/*
 * Object-level authorization check for a specific config entry.
 * SECURE: Checks both role AND tenant scope before allowing access.
 */
static result_t check_object_authorization(const task_identity_t *identity,
					   const config_entry_t *entry,
					   bool is_write)
{
	if (!identity || !entry) {
		return RESULT_DENIED;
	}

	/* Check minimum role requirement */
	role_t required_role = is_write ? entry->min_write_role : entry->min_read_role;
	if (identity->role < required_role) {
		printk("[AUTH] Object-level DENIED: task_id=%u role=%d < required=%d "
		       "for field '%s'\n",
		       identity->task_id, identity->role, required_role, entry->name);
		return RESULT_DENIED;
	}

	/* Check tenant scope */
	if (entry->owner_tenant_id != 0 &&
	    entry->owner_tenant_id != identity->tenant_id &&
	    identity->role < ROLE_ADMIN) {
		printk("[AUTH] Object-level DENIED: tenant mismatch for field '%s'\n",
		       entry->name);
		return RESULT_DENIED;
	}

	/* For writes, double-check the allowlist */
	if (is_write && identity->role < ROLE_ADMIN && !entry->user_writable) {
		printk("[AUTH] Object-level DENIED: field '%s' not user-writable\n",
		       entry->name);
		return RESULT_DENIED;
	}

	return RESULT_SUCCESS;
}

/* ============================================================
 * Privilege request system
 * Users submit requests; admin processes them with full auth checks
 * ============================================================ */

/*
 * Submit a privilege request. The requester's identity is verified
 * server-side against the kernel thread.
 */
static result_t submit_privilege_request(uint32_t claimed_task_id,
					 operation_t operation,
					 config_field_t target_field,
					 const char *value,
					 uint32_t flash_offset,
					 const uint8_t *flash_data,
					 size_t flash_data_len,
					 uint32_t *out_request_id)
{
	/*
	 * SECURE: Verify the caller's identity server-side.
	 * We do NOT trust the claimed_task_id alone - we verify it
	 * against the actual kernel thread making the call.
	 */
	task_identity_t *identity = verify_task_identity(claimed_task_id);
	if (!identity) {
		printk("[REQUEST] DENIED: Identity verification failed for "
		       "claimed task_id=%u\n", claimed_task_id);
		return RESULT_DENIED;
	}

	/*
	 * SECURE: Pre-check authorization before even queuing the request.
	 * This prevents flooding the admin queue with unauthorized requests.
	 */
	result_t auth = check_authorization(identity, operation, target_field);
	if (auth != RESULT_SUCCESS) {
		printk("[REQUEST] Pre-authorization DENIED for task_id=%u op=%d\n",
		       identity->task_id, operation);
		return auth;
	}

	/* Validate input parameters */
	if (value && strlen(value) >= MAX_FIELD_VALUE_LEN) {
		return RESULT_INVALID_PARAM;
	}
	if (flash_data_len > sizeof(((privilege_request_t *)0)->flash_data)) {
		return RESULT_INVALID_PARAM;
	}

	k_mutex_lock(&request_mutex, K_FOREVER);

	/* Find a free request slot */
	privilege_request_t *req = NULL;
	for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
		if (!pending_requests[i].pending && !pending_requests[i].completed) {
			req = &pending_requests[i];
			break;
		}
	}

	if (!req) {
		k_mutex_unlock(&request_mutex);
		printk("[REQUEST] Queue full\n");
		return RESULT_BUSY;
	}

	/* Fill in the request with verified server-side data */
	memset(req, 0, sizeof(*req));
	req->request_id = next_request_id++;
	req->requester_task_id = identity->task_id;       /* Verified, not from client */
	req->requester_tenant_id = identity->tenant_id;   /* Verified, not from client */
	req->operation = operation;
	req->target_field = target_field;

	if (value) {
		strncpy(req->value, value, MAX_FIELD_VALUE_LEN - 1);
		req->value[MAX_FIELD_VALUE_LEN - 1] = '\0';
	}

	req->flash_offset = flash_offset;
	if (flash_data && flash_data_len > 0) {
		memcpy(req->flash_data, flash_data, flash_data_len);
		req->flash_data_len = flash_data_len;
	}

	req->pending = true;
	req->completed = false;
	req->result = RESULT_BUSY;

	if (out_request_id) {
		*out_request_id = req->request_id;
	}

	k_mutex_unlock(&request_mutex);

	printk("[REQUEST] Queued request_id=%u from task_id=%u tenant=%u op=%d\n",
	       req->request_id, identity->task_id, identity->tenant_id, operation);

	/* Signal admin that a request is available */
	k_sem_give(&request_available_sem);

	return RESULT_SUCCESS;
}

/*
 * Wait for a request to complete and get the result.
 */
static result_t wait_for_request_result(uint32_t request_id, uint32_t claimed_task_id,
					k_timeout_t timeout)
{
	/* Verify caller identity */
	task_identity_t *identity = verify_task_identity(claimed_task_id);
	if (!identity) {
		return RESULT_DENIED;
	}

	/* Poll for completion with timeout */
	int64_t start = k_uptime_get();
	int64_t timeout_ms = k_ticks_to_ms_floor64(timeout.ticks);

	while (true) {
		k_mutex_lock(&request_mutex, K_FOREVER);

		for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
			privilege_request_t *req = &pending_requests[i];
			if (req->request_id == request_id && req->completed) {
				/*
				 * SECURE: Verify the requester matches.
				 * A task cannot read another task's request results.
				 */
				if (req->requester_task_id != identity->task_id) {
					k_mutex_unlock(&request_mutex);
					printk("[SECURITY] Task %u tried to read "
					       "request belonging to task %u\n",
					       identity->task_id,
					       req->requester_task_id);
					return RESULT_DENIED;
				}

				result_t result = req->result;
				/* Clear the slot */
				memset(req, 0, sizeof(*req));
				k_mutex_unlock(&request_mutex);
				return result;
			}
		}

		k_mutex_unlock(&request_mutex);

		if ((k_uptime_get() - start) > timeout_ms) {
			return RESULT_BUSY;
		}

		k_sleep(K_MSEC(50));
	}
}

/* ============================================================
 * Admin operations - executed with full privilege
 * ============================================================ */

/*
 * Simulated flash write operation.
 * In a real system, this would use the Zephyr flash API.
 */
static result_t admin_flash_write(uint32_t offset, const uint8_t *data,
				  size_t len, uint32_t admin_task_id,
				  uint32_t requester_tenant_id)
{
	/* Validate parameters */
	if (!data || len == 0 || len > 64) {
		return RESULT_INVALID_PARAM;
	}

	/* Simulated flash boundary check */
	if (offset > 0x100000) {
		printk("[FLASH] Write rejected: offset 0x%x out of range\n", offset);
		return RESULT_FLASH_ERROR;
	}

	/*
	 * In a real implementation:
	 * const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash));
	 * int rc = flash_write(flash_dev, offset, data, len);
	 */

	printk("[FLASH] Write %zu bytes at offset 0x%x (authorized by admin task %u "
	       "for tenant %u)\n", len, offset, admin_task_id, requester_tenant_id);

	audit_log_operation(admin_task_id, requester_tenant_id,
			    OP_FLASH_WRITE, RESULT_SUCCESS, offset, len);

	return RESULT_SUCCESS;
}

/*
 * Simulated flash erase operation.
 */
static result_t admin_flash_erase(uint32_t offset, uint32_t admin_task_id,
				  uint32_t requester_tenant_id)
{
	if (offset > 0x100000) {
		return RESULT_FLASH_ERROR;
	}

	printk("[FLASH] Erase sector at offset 0x%x (authorized by admin task %u "
	       "for tenant %u)\n", offset, admin_task_id, requester_tenant_id);

	audit_log_operation(admin_task_id, requester_tenant_id,
			    OP_FLASH_ERASE, RESULT_SUCCESS, offset, 0);

	return RESULT_SUCCESS;
}

/*
 * Admin config write - with full server-side authorization.
 */
static result_t admin_write_config(config_field_t field, const char *value,
				   uint32_t requester_task_id,
				   uint32_t requester_tenant_id)
{
	/* Look up the requester's full identity server-side */
	task_identity_t *requester = lookup_task_by_id(requester_task_id);
	if (!requester) {
		printk("[CONFIG] Write denied: requester task_id=%u not found\n",
		       requester_task_id);
		return RESULT_NOT_FOUND;
	}

	/*
	 * SECURE: Verify the tenant_id in the request matches the
	 * server-side identity. Never trust client-provided tenant_id.
	 */
	if (requester->tenant_id != requester_tenant_id) {
		printk("[SECURITY] Tenant ID mismatch in request! "
		       "Request says %u, server says %u\n",
		       requester_tenant_id, requester->tenant_id);
		return RESULT_DENIED;
	}

	k_mutex_lock(&config_mutex, K_FOREVER);

	/*
	 * SECURE: Find config entry scoped to the requester's tenant.
	 * This ensures tenant isolation.
	 */
	config_entry_t *entry = find_config_by_field_and_tenant(
		field, requester->tenant_id, requester->role);

	if (!entry) {
		k_mutex_unlock(&config_mutex);
		printk("[CONFIG] Field %d not found for tenant %u\n",
		       field, requester->tenant_id);
		return RESULT_NOT_FOUND;
	}

	/*
	 * SECURE: Object-level authorization check.
	 * Even though the operation was pre-authorized, we check again
	 * at the object level before modifying.
	 */
	result_t auth = check_object_authorization(requester, entry, true);
	if (auth != RESULT_SUCCESS) {
		k_mutex_unlock(&config_mutex);
		return auth;
	}

	/*
	 * SECURE: Final allowlist check - defense in depth.
	 * Even if somehow a privileged field got this far, block it
	 * for non-admin users.
	 */
	if (requester->role < ROLE_ADMIN) {
		if (is_privileged_field(field)) {
			k_mutex_unlock(&config_mutex);
			printk("[SECURITY] BLOCKED: Final allowlist check caught "
			       "privileged field %d from user task %u\n",
			       field, requester_task_id);
			return RESULT_PRIVILEGE_ESCALATION_BLOCKED;
		}
		if (!is_field_user_writable(field)) {
			k_mutex_unlock(&config_mutex);
			return RESULT_DENIED;
		}
	}

	/* Perform the update */
	strncpy(entry->value, value, MAX_FIELD_VALUE_LEN - 1);
	entry->value[MAX_FIELD_VALUE_LEN - 1] = '\0';

	printk("[CONFIG] Updated '%s' = '%s' (by task %u, tenant %u)\n",
	       entry->name, entry->value, requester_task_id, requester->tenant_id);

	k_mutex_unlock(&config_mutex);

	audit_log_operation(requester_task_id, requester->tenant_id,
			    OP_WRITE_CONFIG, RESULT_SUCCESS, 0, 0);

	return RESULT_SUCCESS;
}

/*
 * Admin config read - with authorization.
 */
static result_t admin_read_config(config_field_t field,
				  uint32_t requester_task_id,
				  uint32_t requester_tenant_id,
				  char *out_value, size_t out_len)
{
	task_identity_t *requester = lookup_task_by_id(requester_task_id);
	if (!requester) {
		return RESULT_NOT_FOUND;
	}

	if (requester->tenant_id != requester_tenant_id) {
		printk("[SECURITY] Tenant ID mismatch in read request\n");
		return RESULT_DENIED;
	}

	k_mutex_lock(&config_mutex, K_FOREVER);

	config_entry_t *entry = find_config_by_field_and_tenant(
		field, requester->tenant_id, requester->role);

	if (!entry) {
		k_mutex_unlock(&config_mutex);
		return RESULT_NOT_FOUND;
	}

	/*
	 * SECURE: Object-level authorization before returning data.
	 */
	result_t auth = check_object_authorization(requester, entry, false);
	if (auth != RESULT_SUCCESS) {
		k_mutex_unlock(&config_mutex);
		return auth;
	}

	if (out_value && out_len > 0) {
		strncpy(out_value, entry->value, out_len - 1);
		out_value[out_len - 1] = '\0';
	}

	k_mutex_unlock(&config_mutex);

	printk("[CONFIG] Read '%s' = '%s' (by task %u)\n",
	       entry->name, entry->value, requester_task_id);

	return RESULT_SUCCESS;
}

/* ============================================================
 * Admin task - processes privilege requests
 * ============================================================ */

static void admin_task_entry(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	uint32_t admin_task_id = 1; /* Server-assigned */

	printk("[ADMIN] Admin task started (task_id=%u)\n", admin_task_id);

	while (1) {
		/* Wait for a request */
		k_sem_take(&request_available_sem, K_FOREVER);

		/*
		 * SECURE: Verify admin identity before processing.
		 * Even the admin task must verify itself.
		 */
		task_identity_t *admin_identity = verify_task_identity(admin_task_id);
		if (!admin_identity || admin_identity->role != ROLE_ADMIN) {
			printk("[ADMIN] CRITICAL: Admin identity verification failed!\n");
			continue;
		}

		k_mutex_lock(&request_mutex, K_FOREVER);

		/* Find a pending request */
		privilege_request_t *req = NULL;
		for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
			if (pending_requests[i].pending) {
				req = &pending_requests[i];
				break;
			}
		}

		if (!req) {
			k_mutex_unlock(&request_mutex);
			continue;
		}

		/* Copy request data and mark as being processed */
		privilege_request_t local_req = *req;
		req->pending = false;

		k_mutex_unlock(&request_mutex);

		printk("[ADMIN] Processing request_id=%u from task_id=%u op=%d\n",
		       local_req.request_id, local_req.requester_task_id,
		       local_req.operation);

		/*
		 * SECURE: Re-verify the requester's identity and authorization
		 * at processing time. The requester's permissions may have
		 * changed since the request was queued.
		 */
		task_identity_t *requester = lookup_task_by_id(local_req.requester_task_id);
		if (!requester || !requester->active) {
			printk("[ADMIN] Requester task_id=%u no longer valid\n",
			       local_req.requester_task_id);
			local_req.result = RESULT_DENIED;
			goto complete_request;
		}

		/* Re-check authorization at processing time */
		result_t auth = check_authorization(requester, local_req.operation,
						    local_req.target_field);
		if (auth != RESULT_SUCCESS) {
			printk("[ADMIN] Re-authorization DENIED for request_id=%u\n",
			       local_req.request_id);
			local_req.result = auth;
			goto complete_request;
		}

		/* Process the operation */
		switch (local_req.operation) {
		case OP_FLASH_WRITE:
			local_req.result = admin_flash_write(
				local_req.flash_offset,
				local_req.flash_data,
				local_req.flash_data_len,
				admin_task_id,
				local_req.requester_tenant_id);
			break;

		case OP_FLASH_ERASE:
			local_req.result = admin_flash_erase(
				local_req.flash_offset,
				admin_task_id,
				local_req.requester_tenant_id);
			break;

		case OP_WRITE_CONFIG:
			local_req.result = admin_write_config(
				local_req.target_field,
				local_req.value,
				local_req.requester_task_id,
				local_req.requester_tenant_id);
			break;

		case OP_READ_CONFIG: {
			char read_buf[MAX_FIELD_VALUE_LEN];
			local_req.result = admin_read_config(
				local_req.target_field,
				local_req.requester_task_id,
				local_req.requester_tenant_id,
				read_buf, sizeof(read_buf));
			if (local_req.result == RESULT_SUCCESS) {
				printk("[ADMIN] Config read result: '%s'\n", read_buf);
			}
			break;
		}

		case OP_GET_STATUS:
			printk("[ADMIN] Status: %d registered tasks, "
			       "%d config entries, %d audit entries\n",
			       num_registered_tasks, num_config_entries, audit_index);
			local_req.result = RESULT_SUCCESS;
			break;

		default:
			local_req.result = RESULT_INVALID_PARAM;
			break;
		}

complete_request:
		/* Mark request as completed */
		k_mutex_lock(&request_mutex, K_FOREVER);
		for (int i = 0; i < MAX_PENDING_REQUESTS; i++) {
			if (pending_requests[i].request_id == local_req.request_id) {
				pending_requests[i].result = local_req.result;
				pending_requests[i].completed = true;
				pending_requests[i].pending = false;
				break;
			}
		}
		k_mutex_unlock(&request_mutex);

		printk("[ADMIN] Request_id=%u completed with result=%d\n",
		       local_req.request_id, local_req.result);

		k_sem_give(&request_complete_sem);
	}
}

/* ============================================================
 * User task - submits requests through privilege system
 * ============================================================ */

static void user_task_entry(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	uint32_t user_task_id = 2; /* Server-assigned */
	uint32_t request_id;
	result_t result;

	printk("[USER] User task started (task_id=%u)\n", user_task_id);

	/* Wait for system initialization */
	k_sleep(K_MSEC(500));

	/* ---- Test 1: Legitimate config write (allowlisted field) ---- */
	printk("\n[USER] === Test 1: Write allowlisted field (display_name) ===\n");
	result = submit_privilege_request(
		user_task_id, OP_WRITE_CONFIG, FIELD_DISPLAY_NAME,
		"My Custom Device", 0, NULL, 0, &request_id);

	if (result == RESULT_SUCCESS) {
		result = wait_for_request_result(request_id, user_task_id,
						 K_SECONDS(5));
		printk("[USER] Test 1 result: %d (expected: 0 SUCCESS)\n", result);
	} else {
		printk("[USER] Test 1 submit failed: %d\n", result);
	}

	k_sleep(K_MSEC(200));

	/* ---- Test 2: Legitimate config read ---- */
	printk("\n[USER] === Test 2: Read allowlisted field (log_level) ===\n");
	result = submit_privilege_request(
		user_task_id, OP_READ_CONFIG, FIELD_LOG_LEVEL,
		NULL, 0, NULL, 0, &request_id);

	if (result == RESULT_SUCCESS) {
		result = wait_for_request_result(request_id, user_task_id,
						 K_SECONDS(5));
		printk("[USER] Test 2 result: %d (expected: 0 SUCCESS)\n", result);
	} else {
		printk("[USER] Test 2 submit failed: %d\n", result);
	}

	k_sleep(K_MSEC(200));

	/* ---- Test 3: ATTACK - Try to modify privileged field (role) ---- */
	printk("\n[USER] === Test 3: ATTACK - Modify admin role field ===\n");
	result = submit_privilege_request(
		user_task_id, OP_WRITE_CONFIG, FIELD_ADMIN_ROLE,
		"superadmin", 0, NULL, 0, &request_id);
	printk("[USER] Test 3 result: %d (expected: -7 PRIVILEGE_ESCALATION_BLOCKED)\n",
	       result);

	k_sleep(K_MSEC(200));

	/* ---- Test 4: ATTACK - Try to modify security policy ---- */
	printk("\n[USER] === Test 4: ATTACK - Modify security policy ===\n");
	result = submit_privilege_request(
		user_task_id, OP_WRITE_CONFIG, FIELD_SECURITY_POLICY,
		"permissive", 0, NULL, 0, &request_id);
	printk("[USER] Test 4 result: %d (expected: -7 PRIVILEGE_ESCALATION_BLOCKED)\n",
	       result);

	k_sleep(K_MSEC(200));

	/* ---- Test 5: ATTACK - Try direct flash write (admin-only) ---- */
	printk("\n[USER] === Test 5: ATTACK - Direct flash write ===\n");
	uint8_t malicious_data[] = {0xDE, 0xAD, 0xBE, 0xEF};
	result = submit_privilege_request(
		user_task_id, OP_FLASH_WRITE, FIELD_NONE,
		NULL, 0x1000, malicious_data, sizeof(malicious_data), &request_id);
	printk("[USER] Test 5 result: %d (expected: -1 DENIED)\n", result);

	k_sleep(K_MSEC(200));

	/* ---- Test 6: ATTACK - Try to read admin-only config ---- */
	printk("\n[USER] === Test 6: ATTACK - Read admin-only flash_protection ===\n");
	result = submit_privilege_request(
		user_task_id, OP_READ_CONFIG, FIELD_FLASH_PROTECTION,
		NULL, 0, NULL, 0, &request_id);

	if (result == RESULT_SUCCESS) {
		result = wait_for_request_result(request_id, user_task_id,
						 K_SECONDS(5));
		printk("[USER] Test 6 result: %d (expected: -6 NOT_FOUND due to "
		       "tenant scope)\n", result);
	} else {
		printk("[USER] Test 6 submit failed: %d\n", result);
	}

	k_sleep(K_MSEC(200));

	/* ---- Test 7: Legitimate write to another allowlisted field ---- */
	printk("\n[USER] === Test 7: Write allowlisted field (led_brightness) ===\n");
	result = submit_privilege_request(
		user_task_id, OP_WRITE_CONFIG, FIELD_LED_BRIGHTNESS,
		"75", 0, NULL, 0, &request_id);

	if (result == RESULT_SUCCESS) {
		result = wait_for_request_result(request_id, user_task_id,
						 K_SECONDS(5));
		printk("[USER] Test 7 result: %d (expected: 0 SUCCESS)\n", result);
	} else {
		printk("[USER] Test 7 submit failed: %d\n", result);
	}

	k_sleep(K_MSEC(200));

	/* ---- Test 8: Get system status (allowed for all) ---- */
	printk("\n[USER] === Test 8: Get system status ===\n");
	result = submit_privilege_request(
		user_task_id, OP_GET_STATUS, FIELD_NONE,
		NULL, 0, NULL, 0, &request_id);

	if (result == RESULT_SUCCESS) {
		result = wait_for_request_result(request_id, user_task_id,
						 K_SECONDS(5));
		printk("[USER] Test 8 result: %d (expected: 0 SUCCESS)\n", result);
	} else {
		printk("[USER] Test 8 submit failed: %d\n", result);
	}

	k_sleep(K_MSEC(200));

	/* ---- Test 9: ATTACK - Impersonate admin task ---- */
	printk("\n[USER] === Test 9: ATTACK - Impersonate admin (claim task_id=1) ===\n");
	result = submit_privilege_request(
		1, /* Claiming to be admin task_id=1 */
		OP_FLASH_WRITE, FIELD_NONE,
		NULL, 0x2000, malicious_data, sizeof(malicious_data), &request_id);
	printk("[USER] Test 9 result: %d (expected: -1 DENIED - identity mismatch)\n",
	       result);

	printk("\n[USER] === All tests completed ===\n");

	/* Print audit log summary */
	k_sleep(K_MSEC(500));
	printk("\n[AUDIT] === Audit Log Summary ===\n");
	k_mutex_lock(&audit_mutex, K_FOREVER);
	int count = (audit_index < MAX_AUDIT_ENTRIES) ? audit_index : MAX_AUDIT_ENTRIES;
	for (int i = 0; i < count; i++) {
		audit_entry_t *e = &audit_log[i];
		printk("[AUDIT] t=%u task=%u tenant=%u op=%d result=%d "
		       "flash_off=0x%x len=%zu\n",
		       e->timestamp, e->task_id, e->tenant_id,
		       e->operation, e->result, e->flash_offset, e->data_len);
	}
	k_mutex_unlock(&audit_mutex);

	/* Keep thread alive */
	while (1) {
		k_sleep(K_SECONDS(10));
	}
}

/* ============================================================
 * Main - System initialization
 * ============================================================ */

int main(void)
{
	printk("========================================\n");
	printk("Zephyr RTOS Privilege System\n");
	printk("Secure Admin/User Permission Model\n");
	printk("========================================\n\n");

	/* Initialize configuration */
	init_system_config();

	/* Clear request queue */
	memset(pending_requests, 0, sizeof(pending_requests));

	/* Clear audit log */
	memset(audit_log, 0, sizeof(audit_log));

	/*
	 * Create threads first, then register identities.
	 * SECURE: Identities are assigned by the system, not by the tasks.
	 * Roles are server-assigned and cannot be modified by tasks.
	 */

	/* Create admin thread */
	k_tid_t admin_tid = k_thread_create(
		&admin_thread_data, admin_stack, ADMIN_STACK_SIZE,
		admin_task_entry, NULL, NULL, NULL,
		ADMIN_PRIORITY, 0, K_MSEC(100));
	k_thread_name_set(admin_tid, "admin_task");

	/* Create user thread */
	k_tid_t user_tid = k_thread_create(
		&user_thread_data, user_stack, USER_STACK_SIZE,
		user_task_entry, NULL, NULL, NULL,
		USER_PRIORITY, 0, K_MSEC(200));
	k_thread_name_set(user_tid, "user_task");

	/*
	 * SECURE: Register task identities server-side.
	 * The role and tenant_id are assigned here by the system,
	 * NOT provided by the tasks themselves.
	 * The kernel thread ID is bound to the identity for verification.
	 */
	register_task_identity(1, ROLE_ADMIN, 0, admin_tid);  /* Admin: system tenant */
	register_task_identity(2, ROLE_USER, 1, user_tid);    /* User: tenant 1 */

	printk("[MAIN] System initialized. Admin and User tasks registered.\n\n");

	return 0;
}