# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SECURITY REQUIREMENTS:

Implement this securely to prevent debug interface.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: debug_interface

/**
 * Secure Diagnostic Console for Industrial IoT Sensor Firmware
 * 
 * Security Architecture:
 * - Authentication required before any diagnostic command execution
 * - JTAG disabled by default, requires authenticated unlock with time-limited session
 * - Command allowlist with privilege levels
 * - Memory access restricted to safe regions only
 * - Rate limiting on authentication attempts
 * - Session timeout for automatic re-lock
 * - All diagnostic access is audit-logged
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stddef.h>

/* Platform-specific headers - adjust for your MCU */
/* #include "stm32f4xx_hal.h" */
/* #include "hw_crypto.h" */

/*============================================================================
 * Configuration Constants
 *============================================================================*/

#define DIAG_UART_BAUD_RATE         115200
#define DIAG_MAX_CMD_LEN            128
#define DIAG_MAX_ARGS               8
#define DIAG_MAX_ARG_LEN            32
#define DIAG_SESSION_TIMEOUT_SEC    300   /* 5 minutes */
#define DIAG_MAX_AUTH_ATTEMPTS      3
#define DIAG_LOCKOUT_DURATION_SEC   600   /* 10 minutes after max attempts */
#define DIAG_CHALLENGE_LEN          32
#define DIAG_RESPONSE_LEN           32
#define DIAG_HMAC_KEY_LEN           32
#define DIAG_AUDIT_LOG_MAX_ENTRIES  256
#define DIAG_MAX_DUMP_SIZE          256   /* Max bytes per memory dump request */

/* Memory region access control */
#define MAX_SAFE_REGIONS            8

/*============================================================================
 * Type Definitions
 *============================================================================*/

typedef enum {
    PRIV_NONE = 0,
    PRIV_BASIC = 1,      /* get_config, get_status */
    PRIV_ELEVATED = 2,   /* dump_memory (safe regions), read_flash (safe regions) */
    PRIV_SERVICE = 3     /* JTAG unlock, full diagnostics */
} privilege_level_t;

typedef enum {
    AUTH_STATE_LOCKED = 0,
    AUTH_STATE_CHALLENGE_SENT,
    AUTH_STATE_AUTHENTICATED
} auth_state_t;

typedef enum {
    AUDIT_AUTH_ATTEMPT = 0,
    AUDIT_AUTH_SUCCESS,
    AUDIT_AUTH_FAILURE,
    AUDIT_AUTH_LOCKOUT,
    AUDIT_CMD_EXECUTED,
    AUDIT_CMD_DENIED,
    AUDIT_SESSION_TIMEOUT,
    AUDIT_JTAG_UNLOCK,
    AUDIT_JTAG_LOCK
} audit_event_t;

typedef struct {
    uint32_t start_addr;
    uint32_t end_addr;
    privilege_level_t min_privilege;
    const char *region_name;
} memory_region_t;

typedef struct {
    uint32_t timestamp;
    audit_event_t event;
    uint32_t detail;       /* command index or error code */
    uint8_t session_id[4]; /* truncated session identifier */
} audit_entry_t;

typedef struct {
    const char *name;
    privilege_level_t required_privilege;
    int (*handler)(int argc, const char *argv[]);
    const char *help;
} diag_command_t;

typedef struct {
    auth_state_t auth_state;
    privilege_level_t current_privilege;
    uint32_t session_start_time;
    uint32_t last_activity_time;
    uint32_t auth_attempt_count;
    uint32_t lockout_start_time;
    uint8_t challenge[DIAG_CHALLENGE_LEN];
    uint8_t session_id[4];
    bool jtag_unlocked;
    uint32_t jtag_unlock_time;
} diag_session_t;

/*============================================================================
 * Forward Declarations - Command Handlers
 *============================================================================*/

static int cmd_help(int argc, const char *argv[]);
static int cmd_auth(int argc, const char *argv[]);
static int cmd_logout(int argc, const char *argv[]);
static int cmd_get_status(int argc, const char *argv[]);
static int cmd_get_config(int argc, const char *argv[]);
static int cmd_dump_memory(int argc, const char *argv[]);
static int cmd_read_flash(int argc, const char *argv[]);
static int cmd_jtag_unlock(int argc, const char *argv[]);
static int cmd_jtag_lock(int argc, const char *argv[]);
static int cmd_audit_log(int argc, const char *argv[]);

/*============================================================================
 * Platform Abstraction Layer (implement per target MCU)
 *============================================================================*/

/* These functions must be implemented for your specific hardware platform */

/* Get monotonic time in seconds */
static uint32_t platform_get_time_sec(void);

/* Hardware RNG - fill buffer with random bytes */
static int platform_get_random(uint8_t *buf, size_t len);

/* HMAC-SHA256 using hardware crypto if available */
static int platform_hmac_sha256(const uint8_t *key, size_t key_len,
                                 const uint8_t *data, size_t data_len,
                                 uint8_t *mac, size_t mac_len);

/* Read the HMAC key from secure storage (OTP, secure element, etc.) */
static int platform_get_auth_key(uint8_t *key, size_t key_len);

/* UART operations */
static int platform_uart_init(uint32_t baud_rate);
static int platform_uart_send(const uint8_t *data, size_t len);
static int platform_uart_receive_byte(uint8_t *byte, uint32_t timeout_ms);

/* JTAG control */
static void platform_jtag_disable(void);
static void platform_jtag_enable(void);

/* Flash read */
static int platform_flash_read(uint32_t addr, uint8_t *buf, size_t len);

/* Secure memory comparison (constant time) */
static int platform_secure_compare(const uint8_t *a, const uint8_t *b, size_t len);

/* Write to persistent audit log (e.g., dedicated flash sector) */
static int platform_write_audit_log(const audit_entry_t *entry);

/* Volatile memory clear */
static void platform_secure_memzero(void *ptr, size_t len);

/*============================================================================
 * Platform Stubs (replace with real implementations)
 *============================================================================*/

static volatile uint32_t g_tick_seconds = 0;

static uint32_t platform_get_time_sec(void) {
    return g_tick_seconds;
}

static int platform_get_random(uint8_t *buf, size_t len) {
    /* MUST use hardware RNG in production - e.g., HAL_RNG_GenerateRandomNumber */
    /* This stub is NOT secure */
    (void)buf; (void)len;
    return -1; /* Force failure if not implemented */
}

static int platform_hmac_sha256(const uint8_t *key, size_t key_len,
                                 const uint8_t *data, size_t data_len,
                                 uint8_t *mac, size_t mac_len) {
    /* MUST use hardware crypto or vetted software implementation */
    (void)key; (void)key_len; (void)data; (void)data_len;
    (void)mac; (void)mac_len;
    return -1;
}

static int platform_get_auth_key(uint8_t *key, size_t key_len) {
    /* Read from OTP/secure element - NEVER hardcode */
    (void)key; (void)key_len;
    return -1;
}

static int platform_uart_init(uint32_t baud_rate) {
    (void)baud_rate;
    return 0;
}

static int platform_uart_send(const uint8_t *data, size_t len) {
    (void)data; (void)len;
    return 0;
}

static int platform_uart_receive_byte(uint8_t *byte, uint32_t timeout_ms) {
    (void)byte; (void)timeout_ms;
    return -1;
}

static void platform_jtag_disable(void) {
    /* Example for STM32: remap JTAG pins as GPIO */
    /* __HAL_AFIO_REMAP_SWJ_DISABLE(); */
}

static void platform_jtag_enable(void) {
    /* Re-enable JTAG pins */
    /* __HAL_AFIO_REMAP_SWJ_ENABLE(); */
}

static int platform_flash_read(uint32_t addr, uint8_t *buf, size_t len) {
    /* Bounds-checked flash read */
    (void)addr; (void)buf; (void)len;
    return -1;
}

static int platform_secure_compare(const uint8_t *a, const uint8_t *b, size_t len) {
    volatile uint8_t result = 0;
    for (size_t i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }
    return (result == 0) ? 0 : -1;
}

static int platform_write_audit_log(const audit_entry_t *entry) {
    (void)entry;
    return 0;
}

static void platform_secure_memzero(void *ptr, size_t len) {
    volatile uint8_t *p = (volatile uint8_t *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/*============================================================================
 * Safe Memory Regions Allowlist
 *============================================================================*/

static const memory_region_t g_safe_regions[MAX_SAFE_REGIONS] = {
    /* Application RAM (non-secret areas) */
    { 0x20000000, 0x20004FFF, PRIV_ELEVATED, "app_ram" },
    /* Peripheral registers (read-only diagnostics) */
    { 0x40000000, 0x40000FFF, PRIV_ELEVATED, "periph_status" },
    /* Application flash (non-secret code/data) */
    { 0x08000000, 0x0801FFFF, PRIV_ELEVATED, "app_flash" },
    /* Sensor data buffer */
    { 0x20005000, 0x20005FFF, PRIV_BASIC,    "sensor_data" },
    /* Terminator */
    { 0, 0, PRIV_NONE, NULL }
};

/* Explicitly denied regions - checked first, overrides safe regions */
static const memory_region_t g_denied_regions[] = {
    /* Secret key storage */
    { 0x20006000, 0x20006FFF, PRIV_NONE, "key_storage" },
    /* OTP area */
    { 0x1FFF7800, 0x1FFF7A0F, PRIV_NONE, "otp" },
    /* Option bytes */
    { 0x1FFFC000, 0x1FFFC00F, PRIV_NONE, "option_bytes" },
    /* Terminator */
    { 0, 0, PRIV_NONE, NULL }
};

/*============================================================================
 * Command Table (Allowlist)
 *============================================================================*/

static const diag_command_t g_commands[] = {
    { "help",        PRIV_NONE,     cmd_help,        "Show available commands" },
    { "auth",        PRIV_NONE,     cmd_auth,        "Authenticate: auth <phase>" },
    { "logout",      PRIV_BASIC,    cmd_logout,      "End diagnostic session" },
    { "get_status",  PRIV_BASIC,    cmd_get_status,  "Get device status" },
    { "get_config",  PRIV_BASIC,    cmd_get_config,  "Get device configuration" },
    { "dump_memory", PRIV_ELEVATED, cmd_dump_memory,  "Dump memory: dump_memory <addr> <len>" },
    { "read_flash",  PRIV_ELEVATED, cmd_read_flash,   "Read flash: read_flash <addr> <len>" },
    { "jtag_unlock", PRIV_SERVICE,  cmd_jtag_unlock,  "Temporarily enable JTAG" },
    { "jtag_lock",   PRIV_BASIC,    cmd_jtag_lock,    "Disable JTAG" },
    { "audit_log",   PRIV_ELEVATED, cmd_audit_log,    "View audit log" },
    { NULL,          PRIV_NONE,     NULL,             NULL }
};

/*============================================================================
 * Global State
 *============================================================================*/

static diag_session_t g_session;
static char g_cmd_buffer[DIAG_MAX_CMD_LEN + 1];
static size_t g_cmd_buffer_pos = 0;
static audit_entry_t g_audit_ring[DIAG_AUDIT_LOG_MAX_ENTRIES];
static uint32_t g_audit_write_idx = 0;

/*============================================================================
 * Utility Functions
 *============================================================================*/

static void diag_print(const char *str) {
    platform_uart_send((const uint8_t *)str, strlen(str));
}

static void diag_print_hex_byte(uint8_t b) {
    const char hex[] = "0123456789abcdef";
    char out[2];
    out[0] = hex[(b >> 4) & 0x0F];
    out[1] = hex[b & 0x0F];
    platform_uart_send((const uint8_t *)out, 2);
}

static void diag_print_hex(const uint8_t *data, size_t len) {
    for (size_t i = 0; i < len; i++) {
        diag_print_hex_byte(data[i]);
        if ((i + 1) % 16 == 0) {
            diag_print("\r\n");
        } else if ((i + 1) % 4 == 0) {
            diag_print(" ");
        }
    }
    diag_print("\r\n");
}

static void diag_print_uint32(uint32_t val) {
    char buf[11];
    int i = 10;
    buf[i] = '\0';
    if (val == 0) {
        buf[--i] = '0';
    } else {
        while (val > 0 && i > 0) {
            buf[--i] = '0' + (val % 10);
            val /= 10;
        }
    }
    diag_print(&buf[i]);
}

static int hex_char_to_nibble(char c) {
    if (c >= '0' && c <= '9') return c - '0';
    if (c >= 'a' && c <= 'f') return c - 'a' + 10;
    if (c >= 'A' && c <= 'F') return c - 'A' + 10;
    return -1;
}

static int parse_hex_string(const char *str, uint8_t *out, size_t max_len) {
    size_t slen = strlen(str);
    if (slen % 2 != 0 || slen / 2 > max_len) return -1;
    for (size_t i = 0; i < slen; i += 2) {
        int hi = hex_char_to_nibble(str[i]);
        int lo = hex_char_to_nibble(str[i + 1]);
        if (hi < 0 || lo < 0) return -1;
        out[i / 2] = (uint8_t)((hi << 4) | lo);
    }
    return (int)(slen / 2);
}

static int safe_parse_uint32(const char *str, uint32_t *out) {
    if (str == NULL || *str == '\0') return -1;

    uint32_t result = 0;
    const char *p = str;
    int base = 10;

    /* Check for hex prefix */
    if (p[0] == '0' && (p[1] == 'x' || p[1] == 'X')) {
        base = 16;
        p += 2;
        if (*p == '\0') return -1;
    }

    while (*p != '\0') {
        uint32_t digit;
        if (base == 16) {
            int n = hex_char_to_nibble(*p);
            if (n < 0) return -1;
            digit = (uint32_t)n;
        } else {
            if (*p < '0' || *p > '9') return -1;
            digit = (uint32_t)(*p - '0');
        }

        /* Overflow check */
        if (base == 16) {
            if (result > (UINT32_MAX >> 4)) return -1;
            result = (result << 4) | digit;
        } else {
            if (result > (UINT32_MAX - digit) / 10) return -1;
            result = result * 10 + digit;
        }
        p++;
    }

    *out = result;
    return 0;
}

/*============================================================================
 * Audit Logging
 *============================================================================*/

static void audit_log(audit_event_t event, uint32_t detail) {
    audit_entry_t entry;
    entry.timestamp = platform_get_time_sec();
    entry.event = event;
    entry.detail = detail;
    memcpy(entry.session_id, g_session.session_id, 4);

    /* Write to RAM ring buffer */
    uint32_t idx = g_audit_write_idx % DIAG_AUDIT_LOG_MAX_ENTRIES;
    g_audit_ring[idx] = entry;
    g_audit_write_idx++;

    /* Also persist to flash/EEPROM */
    platform_write_audit_log(&entry);
}

/*============================================================================
 * Session Management
 *============================================================================*/

static void session_reset(void) {
    uint32_t saved_attempts = g_session.auth_attempt_count;
    uint32_t saved_lockout = g_session.lockout_start_time;

    /* Clear sensitive session data */
    platform_secure_memzero(&g_session, sizeof(g_session));

    /* Preserve lockout state across session resets */
    g_session.auth_attempt_count = saved_attempts;
    g_session.lockout_start_time = saved_lockout;
    g_session.auth_state = AUTH_STATE_LOCKED;
    g_session.current_privilege = PRIV_NONE;
    g_session.jtag_unlocked = false;
}

static void session_full_reset(void) {
    platform_secure_memzero(&g_session, sizeof(g_session));
    g_session.auth_state = AUTH_STATE_LOCKED;
    g_session.current_privilege = PRIV_NONE;
    g_session.jtag_unlocked = false;
}

static bool session_is_locked_out(void) {
    if (g_session.auth_attempt_count >= DIAG_MAX_AUTH_ATTEMPTS) {
        uint32_t now = platform_get_time_sec();
        uint32_t elapsed = now - g_session.lockout_start_time;
        if (elapsed < DIAG_LOCKOUT_DURATION_SEC) {
            return true;
        }
        /* Lockout expired, reset attempts */
        g_session.auth_attempt_count = 0;
        g_session.lockout_start_time = 0;
    }
    return false;
}

static bool session_check_timeout(void) {
    if (g_session.auth_state != AUTH_STATE_AUTHENTICATED) {
        return false;
    }

    uint32_t now = platform_get_time_sec();
    uint32_t elapsed = now - g_session.last_activity_time;

    if (elapsed > DIAG_SESSION_TIMEOUT_SEC) {
        audit_log(AUDIT_SESSION_TIMEOUT, 0);
        diag_print("\r\n[SESSION EXPIRED]\r\n");

        /* If JTAG was unlocked, re-lock it */
        if (g_session.jtag_unlocked) {
            platform_jtag_disable();
            audit_log(AUDIT_JTAG_LOCK, 0);
        }

        session_reset();
        return true;
    }
    return false;
}

static void session_update_activity(void) {
    g_session.last_activity_time = platform_get_time_sec();
}

/*============================================================================
 * Memory Access Validation
 *============================================================================*/

static bool is_region_denied(uint32_t addr, uint32_t len) {
    uint32_t end_addr;

    /* Overflow check */
    if (len == 0 || addr > UINT32_MAX - len) return true;
    end_addr = addr + len - 1;

    for (int i = 0; g_denied_regions[i].region_name != NULL; i++) {
        /* Check for any overlap with denied region */
        if (addr <= g_denied_regions[i].end_addr &&
            end_addr >= g_denied_regions[i].start_addr) {
            return true;
        }
    }
    return false;
}

static bool is_memory_access_allowed(uint32_t addr, uint32_t len,
                                      privilege_level_t priv) {
    uint32_t end_addr;

    if (len == 0 || len > DIAG_MAX_DUMP_SIZE) return false;
    if (addr > UINT32_MAX - len) return false;
    end_addr = addr + len - 1;

    /* Check denied regions first */
    if (is_region_denied(addr, len)) return false;

    /* Check if entirely within an allowed region with sufficient privilege */
    for (int i = 0; g_safe_regions[i].region_name != NULL; i++) {
        if (addr >= g_safe_regions[i].start_addr &&
            end_addr <= g_safe_regions[i].end_addr &&
            priv >= g_safe_regions[i].min_privilege) {
            return true;
        }
    }

    return false;
}

/*============================================================================
 * Authentication - Challenge-Response using HMAC-SHA256
 *
 * Protocol:
 *   1. Client sends "auth challenge"
 *   2. Server generates random challenge, sends hex-encoded challenge
 *   3. Client computes HMAC-SHA256(shared_key, challenge) offline
 *   4. Client sends "auth response <hex_hmac> <privilege_level>"
 *   5. Server verifies HMAC and grants requested privilege level
 *
 * The shared key is provisioned per-device in secure storage.
 * Field technicians use a secure tool that holds the key in an HSM/TPM.
 *============================================================================*/

static int auth_generate_challenge(void) {
    if (session_is_locked_out()) {
        diag_print("ERROR: Account locked. Try again later.\r\n");
        return -1;
    }

    if (platform_get_random(g_session.challenge, DIAG_CHALLENGE_LEN) != 0) {
        diag_print("ERROR: RNG failure\r\n");
        return -1;
    }

    g_session.auth_state = AUTH_STATE_CHALLENGE_SENT;

    diag_print("CHALLENGE: ");
    diag_print_hex(g_session.challenge, DIAG_CHALLENGE_LEN);

    return 0;
}

static int auth_verify_response(const char *response_hex, const char *priv_str) {
    uint8_t provided_mac[DIAG_RESPONSE_LEN];
    uint8_t expected_mac[DIAG_RESPONSE_LEN];
    uint8_t auth_key[DIAG_HMAC_KEY_LEN];
    uint32_t requested_priv;
    int ret = -1;

    if (g_session.auth_state != AUTH_STATE_CHALLENGE_SENT) {
        diag_print("ERROR: No pending challenge\r\n");
        return -1;
    }

    if (session_is_locked_out()) {
        diag_print("ERROR: Account locked\r\n");
        g_session.auth_state = AUTH_STATE_LOCKED;
        return -1;
    }

    /* Parse the response */
    int mac_len = parse_hex_string(response_hex, provided_mac, DIAG_RESPONSE_LEN);
    if (mac_len != DIAG_RESPONSE_LEN) {
        diag_print("ERROR: Invalid response format\r\n");
        goto cleanup;
    }

    /* Parse requested privilege level */
    if (safe_parse_uint32(priv_str, &requested_priv) != 0 ||
        requested_priv > PRIV_SERVICE) {
        diag_print("ERROR: Invalid privilege level\r\n");
        goto cleanup;
    }

    /* Get the authentication key from secure storage */
    if (platform_get_auth_key(auth_key, DIAG_HMAC_KEY_LEN) != 0) {
        diag_print("ERROR: Key retrieval failed\r\n");
        goto cleanup;
    }

    /* Compute expected HMAC over challenge + requested privilege */
    uint8_t hmac_input[DIAG_CHALLENGE_LEN + 4];
    memcpy(hmac_input, g_session.challenge, DIAG_CHALLENGE_LEN);
    hmac_input[DIAG_CHALLENGE_LEN + 0] = (uint8_t)(requested_priv >> 24);
    hmac_input[DIAG_CHALLENGE_LEN + 1] = (uint8_t)(requested_priv >> 16);
    hmac_input[DIAG_CHALLENGE_LEN + 2] = (uint8_t)(requested_priv >> 8);
    hmac_input[DIAG_CHALLENGE_LEN + 3] = (uint8_t)(requested_priv);

    if (platform_hmac_sha256(auth_key, DIAG_HMAC_KEY_LEN,
                              hmac_input, sizeof(hmac_input),
                              expected_mac, DIAG_RESPONSE_LEN) != 0) {
        diag_print("ERROR: HMAC computation failed\r\n");
        goto cleanup;
    }

    /* Constant-time comparison */
    if (platform_secure_compare(provided_mac, expected_mac, DIAG_RESPONSE_LEN) != 0) {
        g_session.auth_attempt_count++;
        audit_log(AUDIT_AUTH_FAILURE, g_session.auth_attempt_count);

        if (g_session.auth_attempt_count >= DIAG_MAX_AUTH_ATTEMPTS) {
            g_session.lockout_start_time = platform_get_time_sec();
            audit_log(AUDIT_AUTH_LOCKOUT, 0);
            diag_print("ERROR: Authentication failed. Account locked.\r\n");
        } else {
            diag_print("ERROR: Authentication failed. Attempts remaining: ");
            diag_print_uint32(DIAG_MAX_AUTH_ATTEMPTS - g_session.auth_attempt_count);
            diag_print("\r\n");
        }

        g_session.auth_state = AUTH_STATE_LOCKED;
        goto cleanup;
    }

    /* Authentication successful */
    g_session.auth_state = AUTH_STATE_AUTHENTICATED;
    g_session.current_privilege = (privilege_level_t)requested_priv;
    g_session.session_start_time = platform_get_time_sec();
    g_session.last_activity_time = g_session.session_start_time;
    g_session.auth_attempt_count = 0;

    /* Generate session ID for audit trail */
    platform_get_random(g_session.session_id, 4);

    audit_log(AUDIT_AUTH_SUCCESS, requested_priv);

    diag_print("OK: Authenticated at privilege level ");
    diag_print_uint32(requested_priv);
    diag_print("\r\n");

    ret = 0;

cleanup:
    platform_secure_memzero(auth_key, sizeof(auth_key));
    platform_secure_memzero(expected_mac, sizeof(expected_mac));
    platform_secure_memzero(hmac_input, sizeof(hmac_input));
    /* Invalidate challenge after use (prevent replay) */
    platform_secure_memzero(g_session.challenge, sizeof(g_session.challenge));

    return ret;
}

/*============================================================================
 * Command Handlers
 *============================================================================*/

static int cmd_help(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    diag_print("Available commands:\r\n");
    for (int i = 0; g_commands[i].name != NULL; i++) {
        /* Only show commands the user can access */
        if (g_commands[i].required_privilege <= g_session.current_privilege) {
            diag_print("  ");
            diag_print(g_commands[i].name);
            diag_print(" - ");
            diag_print(g_commands[i].help);
            diag_print(" [priv:");
            diag_print_uint32(g_commands[i].required_privilege);
            diag_print("]\r\n");
        }
    }
    return 0;
}

static int cmd_auth(int argc, const char *argv[]) {
    if (argc < 2) {
        diag_print("Usage: auth challenge | auth response <hmac_hex> <priv_level>\r\n");
        return -1;
    }

    if (strcmp(argv[1], "challenge") == 0) {
        return auth_generate_challenge();
    } else if (strcmp(argv[1], "response") == 0) {
        if (argc < 4) {
            diag_print("Usage: auth response <hmac_hex> <priv_level>\r\n");
            return -1;
        }
        return auth_verify_response(argv[2], argv[3]);
    } else {
        diag_print("ERROR: Unknown auth subcommand\r\n");
        return -1;
    }
}

static int cmd_logout(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    if (g_session.jtag_unlocked) {
        platform_jtag_disable();
        g_session.jtag_unlocked = false;
        audit_log(AUDIT_JTAG_LOCK, 0);
    }

    audit_log(AUDIT_CMD_EXECUTED, 0);
    session_full_reset();
    diag_print("OK: Logged out\r\n");
    return 0;
}

static int cmd_get_status(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    diag_print("Device Status:\r\n");
    diag_print("  Uptime: ");
    diag_print_uint32(platform_get_time_sec());
    diag_print(" sec\r\n");
    diag_print("  Session privilege: ");
    diag_print_uint32(g_session.current_privilege);
    diag_print("\r\n");
    diag_print("  JTAG: ");
    diag_print(g_session.jtag_unlocked ? "UNLOCKED" : "locked");
    diag_print("\r\n");

    /* Add more device-specific status here */
    /* e.g., sensor readings, communication status, error counters */

    return 0;
}

static int cmd_get_config(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    diag_print("Device Configuration:\r\n");
    /* Output non-sensitive configuration only */
    /* NEVER output keys, passwords, tokens, or credentials */
    diag_print("  Firmware version: 1.0.0\r\n");
    diag_print("  Sensor interval: 60 sec\r\n");
    diag_print("  UART baud: ");
    diag_print_uint32(DIAG_UART_BAUD_RATE);
    diag_print("\r\n");

    /* Add more non-sensitive config here */

    return 0;
}

static int cmd_dump_memory(int argc, const char *argv[]) {
    uint32_t addr, len;

    if (argc < 3) {
        diag_print("Usage: dump_memory <hex_addr> <length>\r\n");
        return -1;
    }

    if (safe_parse_uint32(argv[1], &addr) != 0) {
        diag_print("ERROR: Invalid address\r\n");
        return -1;
    }

    if (safe_parse_uint32(argv[2], &len) != 0) {
        diag_print("ERROR: Invalid length\r\n");
        return -1;
    }

    if (len == 0 || len > DIAG_MAX_DUMP_SIZE) {
        diag_print("ERROR: Length must be 1-");
        diag_print_uint32(DIAG_MAX_DUMP_SIZE);
        diag_print("\r\n");
        return -1;
    }

    if (!is_memory_access_allowed(addr, len, g_session.current_privilege)) {
        diag_print("ERROR: Access denied for region 0x");
        diag_print_hex_byte((uint8_t)(addr >> 24));
        diag_print_hex_byte((uint8_t)(addr >> 16));
        diag_print_hex_byte((uint8_t)(addr >> 8));
        diag_print_hex_byte((uint8_t)(addr));
        diag_print("\r\n");
        audit_log(AUDIT_CMD_DENIED, addr);
        return -1;
    }

    diag_print("Memory dump at 0x");
    diag_print_hex_byte((uint8_t)(addr >> 24));
    diag_print_hex_byte((uint8_t)(addr >> 16));
    diag_print_hex_byte((uint8_t)(addr >> 8));
    diag_print_hex_byte((uint8_t)(addr));
    diag_print(", ");
    diag_print_uint32(len);
    diag_print(" bytes:\r\n");

    /* Read and display memory in safe chunks */
    const uint8_t *ptr = (const uint8_t *)(uintptr_t)addr;
    uint8_t line_buf[16];
    uint32_t remaining = len;
    uint32_t offset = 0;

    while (remaining > 0) {
        uint32_t chunk = (remaining > 16) ? 16 : remaining;

        /* Copy to local buffer to avoid repeated volatile reads */
        for (uint32_t i = 0; i < chunk; i++) {
            line_buf[i] = ptr[offset + i];
        }

        /* Print address */
        uint32_t line_addr = addr + offset;
        diag_print_hex_byte((uint8_t)(line_addr >> 24));
        diag_print_hex_byte((uint8_t)(line_addr >> 16));
        diag_print_hex_byte((uint8_t)(line_addr >> 8));
        diag_print_hex_byte((uint8_t)(line_addr));
        diag_print(": ");

        diag_print_hex(line_buf, chunk);

        offset += chunk;
        remaining -= chunk;
    }

    return 0;
}

static int cmd_read_flash(int argc, const char *argv[]) {
    uint32_t addr, len;

    if (argc < 3) {
        diag_print("Usage: read_flash <hex_addr> <length>\r\n");
        return -1;
    }

    if (safe_parse_uint32(argv[1], &addr) != 0) {
        diag_print("ERROR: Invalid address\r\n");
        return -1;
    }

    if (safe_parse_uint32(argv[2], &len) != 0) {
        diag_print("ERROR: Invalid length\r\n");
        return -1;
    }

    if (len == 0 || len > DIAG_MAX_DUMP_SIZE) {
        diag_print("ERROR: Length must be 1-");
        diag_print_uint32(DIAG_MAX_DUMP_SIZE);
        diag_print("\r\n");
        return -1;
    }

    if (!is_memory_access_allowed(addr, len, g_session.current_privilege)) {
        diag_print("ERROR: Flash region access denied\r\n");
        audit_log(AUDIT_CMD_DENIED, addr);
        return -1;
    }

    uint8_t buf[DIAG_MAX_DUMP_SIZE];
    if (platform_flash_read(addr, buf, len) != 0) {
        diag_print("ERROR: Flash read failed\r\n");
        return -1;
    }

    diag_print("Flash at 0x");
    diag_print_hex_byte((uint8_t)(addr >> 24));
    diag_print_hex_byte((uint8_t)(addr >> 16));
    diag_print_hex_byte((uint8_t)(addr >> 8));
    diag_print_hex_byte((uint8_t)(addr));
    diag_print(":\r\n");
    diag_print_hex(buf, len);

    platform_secure_memzero(buf, sizeof(buf));
    return 0;
}

static int cmd_jtag_unlock(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    if (g_session.current_privilege < PRIV_SERVICE) {
        diag_print("ERROR: Insufficient privilege for JTAG unlock\r\n");
        audit_log(AUDIT_CMD_DENIED, 0);
        return -1;
    }

    if (g_session.jtag_unlocked) {
        diag_print("JTAG already unlocked\r\n");
        return 0;
    }

    platform_jtag_enable();
    g_session.jtag_unlocked = true;
    g_session.jtag_unlock_time = platform_get_time_sec();

    audit_log(AUDIT_JTAG_UNLOCK, 0);

    diag_print("WARNING: JTAG enabled. Will auto-disable on session timeout.\r\n");
    diag_print("Use 'jtag_lock' to disable manually.\r\n");

    return 0;
}

static int cmd_jtag_lock(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    platform_jtag_disable();
    g_session.jtag_unlocked = false;

    audit_log(AUDIT_JTAG_LOCK, 0);
    diag_print("OK: JTAG disabled\r\n");

    return 0;
}

static int cmd_audit_log(int argc, const char *argv[]) {
    (void)argc; (void)argv;

    static const char *event_names[] = {
        "AUTH_ATTEMPT", "AUTH_SUCCESS", "AUTH_FAILURE", "AUTH_LOCKOUT",
        "CMD_EXEC", "CMD_DENIED", "SESSION_TIMEOUT", "JTAG_UNLOCK", "JTAG_LOCK"
    };

    uint32_t count = g_audit_write_idx;
    if (count > DIAG_AUDIT_LOG_MAX_ENTRIES) {
        count = DIAG_AUDIT_LOG_MAX_ENTRIES;
    }

    uint32_t start = 0;
    if (g_audit_write_idx > DIAG_AUDIT_LOG_MAX_ENTRIES) {
        start = g_audit_write_idx - DIAG_AUDIT_LOG_MAX_ENTRIES;
    }

    diag_print("Audit Log (");
    diag_print_uint32(count);
    diag_print(" entries):\r\n");

    for (uint32_t i = start; i < g_audit_write_idx; i++) {
        uint32_t idx = i % DIAG_AUDIT_LOG_MAX_ENTRIES;
        audit_entry_t *e = &g_audit_ring[idx];

        diag_print("  T=");
        diag_print_uint32(e->timestamp);
        diag_print(" ");

        if (e->event <= AUDIT_JTAG_LOCK) {
            diag_print(event_names[e->event]);
        } else {
            diag_print("UNKNOWN");
        }

        diag_print(" detail=");
        diag_print_uint32(e->detail);
        diag_print(" sid=");
        diag_print_hex(e->session_id, 4);
    }

    return 0;
}

/*============================================================================
 * Command Parser and Dispatcher
 *============================================================================*/

static int parse_command(char *input, const char **argv, int max_args) {
    int argc = 0;
    char *p = input;
    bool in_token = false;

    while (*p != '\0' && argc < max_args) {
        if (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') {
            *p = '\0';
            in_token = false;
        } else if (!in_token) {
            /* Validate character is printable ASCII */
            if (*p < 0x20 || *p > 0x7E) {
                return -1; /* Invalid character */
            }
            argv[argc++] = p;
            in_token = true;
        } else {
            if (*p < 0x20 || *p > 0x7E) {
                return -1;
            }
        }
        p++;
    }

    return argc;
}

static void dispatch_command(char *input) {
    const char *argv[DIAG_MAX_ARGS];
    int argc;

    /* Check session timeout before processing */
    if (session_check_timeout()) {
        return;
    }

    argc = parse_command(input, argv, DIAG_MAX_ARGS);
    if (argc <= 0) {
        return;
    }

    /* Validate command length */
    if (strlen(argv[0]) > DIAG_MAX_ARG_LEN) {
        diag_print("ERROR: Command too long\r\n");
        return;
    }

    /* Look up command in allowlist */
    const diag_command_t *cmd = NULL;
    int cmd_idx = -1;
    for (int i = 0; g_commands[i].name != NULL; i++) {
        if (strcmp(argv[0], g_commands[i].name) == 0) {
            cmd = &g_commands[i];
            cmd_idx = i;
            break;
        }
    }

    if (cmd == NULL) {
        diag_print("ERROR: Unknown command. Type 'help' for available commands.\r\n");
        return;
    }

    /* Check privilege level */
    if (g_session.current_privilege < cmd->required_privilege) {
        diag_print("ERROR: Insufficient privilege (need level ");
        diag_print_uint32(cmd->required_privilege);
        diag_print(", have ");
        diag_print_uint32(g_session.current_privilege);
        diag_print(")\r\n");
        audit_log(AUDIT_CMD_DENIED, (uint32_t)cmd_idx);
        return;
    }

    /* Update session activity timestamp */
    session_update_activity();

    /* Execute command */
    audit_log(AUDIT_CMD_EXECUTED, (uint32_t)cmd_idx);
    int result = cmd->handler(argc, argv);

    if (result != 0) {
        diag_print("Command returned error ");
        diag_print_uint32((uint32_t)(-result));
        diag_print("\r\n");
    }
}

/*============================================================================
 * Input Processing
 *============================================================================*/

static void process_input_byte(uint8_t byte) {
    /* Handle backspace */
    if (byte == 0x08 || byte == 0x7F) {
        if (g_cmd_buffer_pos > 0) {
            g_cmd_buffer_pos--;
            /* Echo backspace */
            uint8_t bs_seq[] = { 0x08, ' ', 0x08 };
            platform_uart_send(bs_seq, 3);
        }
        return;
    }

    /* Handle enter */
    if (byte == '\r' || byte == '\n') {
        diag_print("\r\n");
        g_cmd_buffer[g_cmd_buffer_pos] = '\0';

        if (g_cmd_buffer_pos > 0) {
            dispatch_command(g_cmd_buffer);
        }

        g_cmd_buffer_pos = 0;
        memset(g_cmd_buffer, 0, sizeof(g_cmd_buffer));

        /* Print prompt */
        if (g_session.auth_state == AUTH_STATE_AUTHENTICATED) {
            diag_print("diag> ");
        } else {
            diag_print("locked> ");
        }
        return;
    }

    /* Only accept printable ASCII */
    if (byte < 0x20 || byte > 0x7E) {
        return;
    }

    /* Buffer overflow protection */
    if (g_cmd_buffer_pos >= DIAG_MAX_CMD_LEN) {
        diag_print("\r\nERROR: Input too long\r\n");
        g_cmd_buffer_pos = 0;
        memset(g_cmd_buffer, 0, sizeof(g_cmd_buffer));
        return;
    }

    g_cmd_buffer[g_cmd_buffer_pos++] = (char)byte;

    /* Echo character (but not for auth response to avoid shoulder surfing) */
    /* In a real implementation, you might suppress echo during auth */
    platform_uart_send(&byte, 1);
}

/*============================================================================
 * Public API
 *============================================================================*/

/**
 * Initialize the diagnostic console.
 * Call once during system startup.
 */
int diag_console_init(void) {
    /* Initialize session state */
    session_full_reset();

    /* Clear command buffer */
    memset(g_cmd_buffer, 0, sizeof(g_cmd_buffer));
    g_cmd_buffer_pos = 0;

    /* Clear audit log */
    memset(g_audit_ring, 0, sizeof(g_audit_ring));
    g_audit_write_idx = 0;

    /* Disable JTAG by default */
    platform_jtag_disable();

    /* Initialize UART */
    if (platform_uart_init(DIAG_UART_BAUD_RATE) != 0) {
        return -1;
    }

    diag_print("\r\n");
    diag_print("========================================\r\n");
    diag_print("  Industrial IoT Sensor Diagnostic Console\r\n");
    diag_print("  Authentication required for access.\r\n");
    diag_print("  Type 'help' for available commands.\r\n");
    diag_print("========================================\r\n");
    diag_print("locked> ");

    return 0;
}

/**
 * Process incoming UART data.
 * Call this from the main loop or UART interrupt handler.
 */
void diag_console_poll(void) {
    uint8_t byte;

    /* Check for session timeout periodically */
    session_check_timeout();

    /* Check if JTAG should be auto-locked */
    if (g_session.jtag_unlocked &&
        g_session.auth_state != AUTH_STATE_AUTHENTICATED) {
        platform_jtag_disable();
        g_session.jtag_unlocked = false;
        audit_log(AUDIT_JTAG_LOCK, 0);
    }

    /* Try to receive a byte with short timeout */
    if (platform_uart_receive_byte(&byte, 10) == 0) {
        process_input_byte(byte);
    }
}

/**
 * Main entry point example showing integration.
 */
int main(void) {
    /* System initialization would go here */
    /* HAL_Init(); */
    /* SystemClock_Config(); */

    if (diag_console_init() != 0) {
        /* Handle initialization failure */
        while (1) {
            /* Error state */
        }
    }

    /* Main loop */
    while (1) {
        /* Normal application tasks */
        /* sensor_read(); */
        /* data_process(); */
        /* network_send(); */

        /* Service diagnostic console */
        diag_console_poll();

        /* Update tick counter (normally done in SysTick handler) */
        /* g_tick_seconds updated by interrupt */
    }

    return 0;
}