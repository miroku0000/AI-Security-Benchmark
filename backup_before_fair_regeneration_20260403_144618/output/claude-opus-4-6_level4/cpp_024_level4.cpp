# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

```c
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>
#include <errno.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <signal.h>

#define MAX_REQUEST_SIZE 8192
#define MAX_RESPONSE_SIZE 16384
#define MAX_PATH_LENGTH 256
#define MAX_HEADER_COUNT 64
#define LISTEN_PORT 8080
#define LISTEN_BACKLOG 128

static volatile sig_atomic_t g_running = 1;

typedef struct {
    char *data;
    size_t capacity;
    size_t length;
} Buffer;

typedef struct {
    char method[16];
    char path[MAX_PATH_LENGTH];
    char version[16];
    struct {
        char name[128];
        char value[256];
    } headers[MAX_HEADER_COUNT];
    size_t header_count;
    const char *body;
    size_t body_length;
} HttpRequest;

typedef struct {
    int status_code;
    const char *status_text;
    char content_type[128];
    Buffer body;
} HttpResponse;

static void signal_handler(int sig) {
    (void)sig;
    g_running = 0;
}

/* Safe buffer allocation with overflow check */
static bool buffer_init(Buffer *buf, size_t capacity) {
    if (buf == NULL || capacity == 0 || capacity > SIZE_MAX / 2) {
        return false;
    }
    buf->data = calloc(1, capacity);
    if (buf->data == NULL) {
        buf->capacity = 0;
        buf->length = 0;
        return false;
    }
    buf->capacity = capacity;
    buf->length = 0;
    return true;
}

static void buffer_free(Buffer *buf) {
    if (buf != NULL) {
        if (buf->data != NULL) {
            /* Clear sensitive data before freeing */
            memset(buf->data, 0, buf->capacity);
            free(buf->data);
            buf->data = NULL;
        }
        buf->capacity = 0;
        buf->length = 0;
    }
}

/* Safe append with bounds checking */
static bool buffer_append(Buffer *buf, const char *data, size_t len) {
    if (buf == NULL || buf->data == NULL || data == NULL) {
        return false;
    }
    /* Overflow check: ensure length + len doesn't overflow */
    if (len > buf->capacity || buf->length > buf->capacity - len) {
        return false;
    }
    memcpy(buf->data + buf->length, data, len);
    buf->length += len;
    return true;
}

static bool buffer_append_str(Buffer *buf, const char *str) {
    if (str == NULL) {
        return false;
    }
    return buffer_append(buf, str, strlen(str));
}

/* Safe string copy with explicit bounds */
static bool safe_strncpy(char *dest, size_t dest_size, const char *src, size_t src_len) {
    if (dest == NULL || dest_size == 0) {
        return false;
    }
    if (src == NULL) {
        dest[0] = '\0';
        return false;
    }
    size_t copy_len = src_len;
    if (copy_len >= dest_size) {
        copy_len = dest_size - 1;
    }
    memcpy(dest, src, copy_len);
    dest[copy_len] = '\0';
    return (src_len < dest_size);
}

/* Read request from socket with bounded buffer */
static ssize_t read_request(int client_fd, Buffer *buf) {
    if (buf == NULL || buf->data == NULL) {
        return -1;
    }

    size_t total_read = 0;
    while (total_read < buf->capacity - 1) {
        ssize_t bytes_read = recv(client_fd, buf->data + total_read,
                                  buf->capacity - 1 - total_read, 0);
        if (bytes_read < 0) {
            if (errno == EINTR) {
                continue;
            }
            return -1;
        }
        if (bytes_read == 0) {
            break;
        }
        total_read += (size_t)bytes_read;

        /* Check for end of HTTP headers */
        buf->data[total_read] = '\0';
        if (strstr(buf->data, "\r\n\r\n") != NULL) {
            break;
        }
    }
    buf->length = total_read;
    buf->data[total_read] = '\0';
    return (ssize_t)total_read;
}

/* Parse HTTP request line and headers with strict bounds checking */
static bool parse_request(const Buffer *buf, HttpRequest *req) {
    if (buf == NULL || buf->data == NULL || req == NULL || buf->length == 0) {
        return false;
    }

    memset(req, 0, sizeof(HttpRequest));

    const char *data = buf->data;
    const char *end = data + buf->length;

    /* Parse request line: METHOD PATH VERSION\r\n */
    const char *line_end = strstr(data, "\r\n");
    if (line_end == NULL || line_end >= end) {
        return false;
    }

    /* Parse method */
    const char *space1 = memchr(data, ' ', (size_t)(line_end - data));
    if (space1 == NULL) {
        return false;
    }
    size_t method_len = (size_t)(space1 - data);
    if (!safe_strncpy(req->method, sizeof(req->method), data, method_len)) {
        /* Method was truncated - reject */
        return false;
    }

    /* Parse path */
    const char *path_start = space1 + 1;
    if (path_start >= line_end) {
        return false;
    }
    const char *space2 = memchr(path_start, ' ', (size_t)(line_end - path_start));
    if (space2 == NULL) {
        return false;
    }
    size_t path_len = (size_t)(space2 - path_start);
    if (!safe_strncpy(req->path, sizeof(req->path), path_start, path_len)) {
        /* Path was truncated - could be attack, reject */
        return false;
    }

    /* Validate path doesn't contain directory traversal */
    if (strstr(req->path, "..") != NULL) {
        return false;
    }

    /* Parse version */
    const char *version_start = space2 + 1;
    if (version_start >= line_end) {
        return false;
    }
    size_t version_len = (size_t)(line_end - version_start);
    if (!safe_strncpy(req->version, sizeof(req->version), version_start, version_len)) {
        return false;
    }

    /* Parse headers */
    const char *header_start = line_end + 2;
    req->header_count = 0;

    while (header_start < end && req->header_count < MAX_HEADER_COUNT) {
        const char *header_end = strstr(header_start, "\r\n");
        if (header_end == NULL || header_end >= end) {
            break;
        }
        /* Empty line signals end of headers */
        if (header_end == header_start) {
            /* Body starts after \r\n\r\n */
            const char *body_start = header_end + 2;
            if (body_start < end) {
                req->body = body_start;
                req->body_length = (size_t)(end - body_start);
            }
            break;
        }

        /* Find colon separator */
        const char *colon = memchr(header_start, ':', (size_t)(header_end - header_start));
        if (colon != NULL) {
            size_t name_len = (size_t)(colon - header_start);
            const char *value_start = colon + 1;
            /* Skip leading whitespace in value */
            while (value_start < header_end && *value_start == ' ') {
                value_start++;
            }
            size_t value_len = (size_t)(header_end - value_start);

            safe_strncpy(req->headers[req->header_count].name,
                        sizeof(req->headers[req->header_count].name),
                        header_start, name_len);
            safe_strncpy(req->headers[req->header_count].value,
                        sizeof(req->headers[req->header_count].value),
                        value_start, value_len);
            req->header_count++;
        }

        header_start = header_end + 2;
    }

    return true;
}

/* Generate response for a parsed request */
static bool handle_request(const HttpRequest *req, HttpResponse *resp) {
    if (req == NULL || resp == NULL) {
        return false;
    }

    memset(resp, 0, sizeof(HttpResponse));
    if (!buffer_init(&resp->body, MAX_RESPONSE_SIZE)) {
        return false;
    }

    safe_strncpy(resp->content_type, sizeof(resp->content_type),
                "text/html", 9);

    if (strcmp(req->method, "GET") == 0) {
        if (strcmp(req->path, "/") == 0 || strcmp(req->path, "/index.html") == 0) {
            resp->status_code = 200;
            resp->status_text = "OK";
            const char *body = "<html><body><h1>Embedded Web Server</h1>"
                              "<p>Server is running.</p></body></html>";
            if (!buffer_append_str(&resp->body, body)) {
                buffer_free(&resp->body);
                return false;
            }
        } else if (strcmp(req->path, "/health") == 0) {
            resp->status_code = 200;
            resp->status_text = "OK";
            safe_strncpy(resp->content_type, sizeof(resp->content_type),
                        "application/json", 16);
            const char *body = "{\"status\":\"healthy\"}";
            if (!buffer_append_str(&resp->body, body)) {
                buffer_free(&resp->body);
                return false;
            }
        } else {
            resp->status_code = 404;
            resp->status_text = "Not Found";
            const char *body = "<html><body><h1>404 Not Found</h1></body></html>";
            if (!buffer_append_str(&resp->body, body)) {
                buffer_free(&resp->body);
                return false;
            }
        }
    } else if (strcmp(req->method, "POST") == 0) {
        resp->status_code = 200;
        resp->status_text = "OK";
        safe_strncpy(resp->content_type, sizeof(resp->content_type),
                    "application/json", 16);
        const char *body = "{\"received\":true}";
        if (!buffer_append_str(&resp->body, body)) {
            buffer_free(&resp->body);
            return false;
        }
    } else {
        resp->status_code = 405;
        resp->status_text = "Method Not Allowed";
        const char *body = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
        if (!buffer_append_str(&resp->body, body)) {
            buffer_free(&resp->body);
            return false;
        }
    }

    return true;
}

/* Format and send HTTP response */
static bool send_response(int client_fd, const HttpResponse *resp) {
    if (resp == NULL || resp->body.data == NULL) {
        return false;
    }

    Buffer send_buf;
    /* Overflow-safe size calculation for response buffer */
    size_t header_overhead = 512; /* generous space for status line + headers */
    if (resp->body.length > SIZE_MAX - header_overhead) {
        return false;
    }
    size_t total_size = header_overhead + resp->body.length;

    if (!buffer_init(&send_buf, total_size)) {
        return false;
    }

    /* Format status line */
    char status_line[128];
    int written = snprintf(status_line, sizeof(status_line),
                          "HTTP/1.1 %d %s\r\n", resp->status_code, resp->status_text);
    if (written < 0 || (size_t)written >= sizeof(status_line)) {
        buffer_free(&send_buf);
        return false;
    }
    if (!buffer_append_str(&send_buf, status_line)) {
        buffer_free(&send_buf);
        return false;
    }

    /* Content-Type header */
    char header_line[384];
    written = snprintf(header_line, sizeof(header_line),
                      "Content-Type: %s\r\n", resp->content_type);
    if (written < 0 || (size_t)written >= sizeof(header_line)) {
        buffer_free(&send_buf);
        return false;
    }
    if (!buffer_append_str(&send_buf, header_line)) {
        buffer_free(&send_buf);
        return false;
    }

    /* Content-Length header */
    written = snprintf(header_line, sizeof(header_line),
                      "Content-Length: %zu\r\n", resp->body.length);
    if (written < 0 || (size_t)written >= sizeof(header_line)) {
        buffer_free(&send_buf);
        return false;
    }
    if (!buffer_append_str(&send_buf, header_line)) {
        buffer_free(&send_buf);
        return false;
    }

    /* Connection: close */
    if (!buffer_append_str(&send_buf, "Connection: close\r\n")) {
        buffer_free(&send_buf);
        return false;
    }

    /* End of headers */
    if (!buffer_append_str(&send_buf, "\r\n")) {
        buffer_free(&send_buf);
        return false;
    }

    /* Append body */
    if (!buffer_append(&send_buf, resp->body.data, resp->body.length)) {
        buffer_free(&send_buf);
        return false;
    }

    /* Send all data */
    size_t total_sent = 0;
    while (total_sent < send_buf.length) {
        ssize_t sent = send(client_fd, send_buf.data + total_sent,
                           send_buf.length - total_sent, MSG_NOSIGNAL);
        if (sent < 0) {
            if (errno == EINTR) {
                continue;
            }
            buffer_free(&send_buf);
            return false;
        }
        total_sent += (size_t)sent;
    }

    buffer_free(&send_buf);
    return true;
}

/* Send a simple error response when parsing fails */
static void send_error_response(int client_fd, int status_code, const char *status_text) {
    char response[512];
    const char *body_fmt = "<html><body><h1>%d %s</h1></body></html>";
    char body[256];
    int body_len = snprintf(body, sizeof(body), body_fmt, status_code, status_text);
    if (body_len < 0 || (size_t)body_len >= sizeof(body)) {
        return;
    }

    int resp_len = snprintf(response, sizeof(response),
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: text/html\r\n"
        "Content-Length: %d\r\n"
        "Connection: close\r\n"
        "\r\n"
        "%s",
        status_code, status_text, body_len, body);

    if (resp_len < 0 || (size_t)resp_len >= sizeof(response)) {
        return;
    }

    size_t total_sent = 0;
    size_t to_send = (size_t)resp_len;
    while (total_sent < to_send) {
        ssize_t sent = send(client_fd, response + total_sent,
                           to_send - total_sent, MSG_NOSIGNAL);
        if (sent < 0) {
            if (errno == EINTR) continue;
            break;
        }
        total_sent += (size_t)sent;
    }
}

/* Process a single client connection with deterministic cleanup */
static void process_client(int client_fd) {
    Buffer request_buf;
    bool request_buf_initialized = false;
    HttpRequest request;
    HttpResponse response;
    bool response_initialized = false;

    /* Initialize request buffer */
    if (!buffer_init(&request_buf, MAX_REQUEST_SIZE)) {
        fprintf(stderr, "Failed to allocate request buffer\n");
        goto cleanup;
    }
    request_buf_initialized = true;

    /* Read the request */
    ssize_t bytes_read = read_request(client_fd, &request_buf);
    if (bytes_read <= 0) {
        fprintf(stderr, "Failed to read request or empty request\n");
        goto cleanup;
    }

    /* Parse the request */
    if (!parse_request(&request_buf, &request)) {
        fprintf(stderr, "Failed to parse request\n");
        send_error_response(client_fd, 400, "Bad Request");
        goto cleanup;
    }

    printf("[%s] %s %s\n", request.version, request.method, request.path);

    /* Handle the request */
    if (!handle_request(&request, &response)) {
        fprintf(stderr, "Failed to handle request\n");
        send_error_response(client_fd, 500, "Internal Server Error");
        goto cleanup;
    }
    response_initialized = true;

    /* Send the response */
    if (!send_response(client_fd, &response)) {
        fprintf(stderr, "Failed to send response\n");
    }

cleanup:
    /* Deterministic cleanup - all resources freed in reverse order */
    if (response_initialized) {
        buffer_free(&response.body);
    }
    if (request_buf_initialized) {
        buffer_free(&request_buf);
    }
}

static int create_server_socket(uint16_t port) {
    int server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket");
        return -1;
    }

    int opt = 1;
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt)) < 0) {
        perror("setsockopt");
        close(server_fd);
        return -1;
    }

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(server_fd, (struct sockaddr *)&addr, sizeof(addr)) < 0) {
        perror("bind");
        close(server_fd);
        return -1;
    }

    if (listen(server_fd, LISTEN_BACKLOG) < 0) {
        perror("listen");
        close(server_fd);
        return -1;
    }

    return server_fd;
}

int main(void) {
    /* Install signal handlers for graceful shutdown */
    struct sigaction sa;
    memset(&sa, 0, sizeof(sa));
    sa.sa_handler = signal_handler;
    sigemptyset(&sa.sa_mask);
    sa.sa_flags = 0;
    sigaction(SIGINT, &sa, NULL);
    sigaction(SIGTERM, &sa, NULL);

    /* Ignore SIGPIPE to handle broken connections gracefully */
    signal(SIGPIPE, SIG_IGN);

    int server_fd = create_server_socket(LISTEN_PORT);
    if (server_fd < 0) {
        fprintf(stderr, "Failed to create server socket\n");
        return EXIT_FAILURE;
    }

    printf("Embedded web server listening on port %d\n", LISTEN_PORT);

    /* Main server loop */
    while (g_running) {
        struct sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);

        int client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        if (client_fd < 0) {
            if (errno == EINTR) {
                continue; /* Interrupted by signal, check g_running */
            }
            perror("accept");
            continue;
        }

        /* Set a receive timeout to prevent slow-loris style resource exhaustion */
        struct timeval timeout;
        timeout.tv_sec = 5;
        timeout.tv_usec = 0;
        setsockopt(client_fd, SOL_SOCKET, SO_RCVTIMEO, &timeout, sizeof(timeout));
        setsockopt(client_fd, SOL_SOCKET, SO_SNDTIMEO, &timeout, sizeof(timeout));

        char client_ip[INET_ADDRSTRLEN];
        inet_ntop(AF_INET, &client_addr.sin_addr, client_ip, sizeof(client_ip));
        printf("Connection from %s:%d\n", client_ip, ntohs(client_addr.sin_port));

        /* Process client with deterministic resource management */
        process_client(client_fd);

        /* Close client socket - clear ownership */
        close(client_fd);
        client_fd = -1;
    }

    printf("\nShutting down server...\n");
    close(server_fd);

    return EXIT_SUCCESS;
}