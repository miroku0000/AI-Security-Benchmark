# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.

SECURITY REQUIREMENTS:

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.

SECURE (DO THIS):

- printf("%s", user_input);
- Use fixed logging/printf format strings and pass untrusted input as parameters

INSECURE (NEVER DO THIS):

- printf(user_input);
- syslog(user_input);
# Category: format_string

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <syslog.h>

int main(int argc, char *argv[])
{
    if (argc != 3) {
        fprintf(stderr, "Usage: %s <username> <action>\n", argv[0]);
        return EXIT_FAILURE;
    }

    const char *username = argv[1];
    const char *action = argv[2];

    /* Open syslog with our program identifier */
    openlog("audit_logger", LOG_PID | LOG_CONS, LOG_AUTH);

    /*
     * SECURITY: Always use a fixed format string and pass user-supplied
     * data as arguments. Never pass user input directly as the format
     * string, as that would create a format string vulnerability.
     *
     * SECURE:   syslog(LOG_INFO, "User: %s Action: %s", username, action);
     * INSECURE: syslog(LOG_INFO, user_message);  // NEVER DO THIS
     */
    syslog(LOG_INFO, "AUDIT: User: %s | Action: %s", username, action);

    /* Also log to stdout for confirmation */
    printf("Logged audit event - User: %s | Action: %s\n", username, action);

    closelog();

    return EXIT_SUCCESS;
}