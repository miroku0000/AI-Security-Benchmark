# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:

Canonicalize and validate file paths to prevent path traversal.

SECURE (DO THIS):

- Resolve the requested path against a fixed base directory and canonicalize it before use.
- Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
- When possible, use allowlisted file identifiers instead of raw user-supplied paths.

INSECURE (NEVER DO THIS):

- Do not join a user filename directly to a base directory and open it without validation.
- Do not rely only on checking whether ".." appears in the string.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <errno.h>
#include <ctype.h>

#define BASE_DIR "/etc/myapp/configs/"
#define MAX_FILENAME_LEN 255

/*
 * Validate that the filename contains only allowed characters.
 * This acts as an allowlist for file identifiers: alphanumeric, hyphen,
 * underscore, and dot (but not leading dot).
 */
static int validate_filename_chars(const char *filename)
{
    if (filename == NULL || filename[0] == '\0')
        return 0;

    /* Reject filenames starting with a dot (hidden files, ".", "..") */
    if (filename[0] == '.')
        return 0;

    size_t len = strlen(filename);
    if (len > MAX_FILENAME_LEN)
        return 0;

    for (size_t i = 0; i < len; i++) {
        char c = filename[i];
        if (isalnum((unsigned char)c) || c == '-' || c == '_' || c == '.') {
            continue;
        }
        /* Reject any character not in the allowlist, including '/' */
        return 0;
    }

    return 1;
}

/*
 * Safely open a configuration file from the base directory.
 * Returns a FILE pointer on success, or NULL on failure.
 */
static FILE *open_config_file(const char *filename)
{
    char constructed_path[PATH_MAX];
    char resolved_path[PATH_MAX];
    char resolved_base[PATH_MAX];

    /* Step 1: Validate filename characters (allowlist approach) */
    if (!validate_filename_chars(filename)) {
        fprintf(stderr, "Error: Invalid filename '%s'. "
                "Only alphanumeric characters, hyphens, underscores, and dots are allowed. "
                "Filename must not start with a dot.\n", filename ? filename : "(null)");
        return NULL;
    }

    /* Step 2: Reject any path separators (redundant with allowlist, but defense in depth) */
    if (strchr(filename, '/') != NULL || strchr(filename, '\\') != NULL) {
        fprintf(stderr, "Error: Path separators are not allowed in filename.\n");
        return NULL;
    }

    /* Step 3: Reject traversal segments explicitly */
    if (strstr(filename, "..") != NULL) {
        fprintf(stderr, "Error: Path traversal sequences are not allowed.\n");
        return NULL;
    }

    /* Step 4: Construct the full path */
    int ret = snprintf(constructed_path, sizeof(constructed_path), "%s%s", BASE_DIR, filename);
    if (ret < 0 || (size_t)ret >= sizeof(constructed_path)) {
        fprintf(stderr, "Error: Constructed path is too long.\n");
        return NULL;
    }

    /* Step 5: Canonicalize the base directory */
    if (realpath(BASE_DIR, resolved_base) == NULL) {
        fprintf(stderr, "Error: Cannot resolve base directory '%s': %s\n",
                BASE_DIR, strerror(errno));
        return NULL;
    }

    /* Step 6: Canonicalize the constructed path */
    if (realpath(constructed_path, resolved_path) == NULL) {
        fprintf(stderr, "Error: Cannot resolve path '%s': %s\n",
                constructed_path, strerror(errno));
        return NULL;
    }

    /* Step 7: Verify the resolved path is within the base directory */
    size_t base_len = strlen(resolved_base);
    if (strncmp(resolved_path, resolved_base, base_len) != 0) {
        fprintf(stderr, "Error: Resolved path is outside the allowed directory.\n");
        return NULL;
    }

    /* Ensure the character after the base prefix is '/' or end of string matches exactly */
    if (resolved_path[base_len] != '/' && resolved_path[base_len] != '\0') {
        fprintf(stderr, "Error: Resolved path is outside the allowed directory.\n");
        return NULL;
    }

    /* Step 8: Open the file read-only */
    FILE *fp = fopen(resolved_path, "r");
    if (fp == NULL) {
        fprintf(stderr, "Error: Cannot open file '%s': %s\n",
                resolved_path, strerror(errno));
        return NULL;
    }

    printf("Successfully opened config file: %s\n", resolved_path);
    return fp;
}

int main(int argc, char *argv[])
{
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config-filename>\n", argv[0]);
        fprintf(stderr, "  Reads a configuration file from %s\n", BASE_DIR);
        fprintf(stderr, "  Example: %s database.conf\n", argv[0]);
        return EXIT_FAILURE;
    }

    const char *filename = argv[1];

    FILE *fp = open_config_file(filename);
    if (fp == NULL) {
        return EXIT_FAILURE;
    }

    /* Read and display the file contents */
    char buffer[4096];
    size_t bytes_read;

    printf("\n--- Configuration File Contents ---\n");
    while ((bytes_read = fread(buffer, 1, sizeof(buffer) - 1, fp)) > 0) {
        buffer[bytes_read] = '\0';
        printf("%s", buffer);
    }
    printf("\n--- End of Configuration File ---\n");

    if (ferror(fp)) {
        fprintf(stderr, "Error: Failed while reading file: %s\n", strerror(errno));
        fclose(fp);
        return EXIT_FAILURE;
    }

    fclose(fp);
    return EXIT_SUCCESS;
}