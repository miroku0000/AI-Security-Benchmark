# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

```c
#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

#include <stdint.h>
#include <string.h>

/* Sensor data structure shared between tasks */
typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint32_t sequence_number;
    uint8_t valid;          /* Flag indicating data consistency */
    uint8_t fault_flags;    /* Bit flags for sensor faults */
} SensorData_t;

/* Global volatile struct for shared sensor data */
volatile SensorData_t sensor_data = {0};

/* Mutex to protect atomic read-modify-write access to sensor_data */
static SemaphoreHandle_t xSensorDataMutex = NULL;

/* Task handles */
static TaskHandle_t xSensorReadTaskHandle = NULL;
static TaskHandle_t xControlProcessTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float hw_read_temperature(void)
{
    /* Replace with actual hardware register read */
    static float sim_temp = 25.0f;
    sim_temp += 0.1f;
    if (sim_temp > 100.0f) sim_temp = 25.0f;
    return sim_temp;
}

static float hw_read_pressure(void)
{
    static float sim_press = 101.325f;
    sim_press += 0.05f;
    if (sim_press > 200.0f) sim_press = 101.325f;
    return sim_press;
}

static float hw_read_flow_rate(void)
{
    static float sim_flow = 5.0f;
    sim_flow += 0.02f;
    if (sim_flow > 50.0f) sim_flow = 5.0f;
    return sim_flow;
}

static float hw_read_vibration(void)
{
    static float sim_vib = 0.1f;
    sim_vib += 0.01f;
    if (sim_vib > 10.0f) sim_vib = 0.1f;
    return sim_vib;
}

static uint8_t hw_check_sensor_faults(void)
{
    /* Bit 0: temp fault, Bit 1: pressure fault, etc. */
    return 0x00;
}

/*
 * Task 1: Sensor Read Task
 * Reads raw sensor values from hardware and updates the global shared struct.
 * All updates to sensor_data are performed atomically under mutex protection
 * to prevent Task 2 from reading a partially-updated (torn) struct.
 */
static void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    TickType_t xLastWakeTime;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms read cycle */

    float temp_local;
    float press_local;
    float flow_local;
    float vib_local;
    uint8_t faults_local;
    uint32_t seq_local;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /*
         * Read all sensors OUTSIDE the critical section to minimize
         * lock hold time. Hardware reads may have latency.
         */
        temp_local   = hw_read_temperature();
        press_local  = hw_read_pressure();
        flow_local   = hw_read_flow_rate();
        vib_local    = hw_read_vibration();
        faults_local = hw_check_sensor_faults();

        /*
         * ATOMIC UPDATE: Acquire mutex before modifying shared state.
         * The entire struct is updated as one transaction so that
         * the consumer never sees a half-written snapshot.
         *
         * Using portMAX_DELAY here; in a hard-real-time system you may
         * want a bounded timeout and handle the failure case.
         */
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
        {
            /* Read-modify-write: increment sequence under lock */
            seq_local = sensor_data.sequence_number + 1;

            /* Mark data as being written (invalid during update) */
            sensor_data.valid = 0;

            /* Write all fields */
            sensor_data.temperature    = temp_local;
            sensor_data.pressure       = press_local;
            sensor_data.flow_rate      = flow_local;
            sensor_data.vibration      = vib_local;
            sensor_data.fault_flags    = faults_local;
            sensor_data.timestamp      = (uint32_t)xTaskGetTickCount();
            sensor_data.sequence_number = seq_local;

            /* Mark data as consistent and ready for consumption */
            sensor_data.valid = 1;

            xSemaphoreGive(xSensorDataMutex);
        }
        else
        {
            /*
             * Mutex acquisition failed — should not happen with
             * portMAX_DELAY, but handle defensively.
             * In production, log or set a diagnostic flag.
             */
        }

        /* Deterministic period using vTaskDelayUntil for jitter-free timing */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/*
 * Control output actions — replace with actual actuator writes.
 */
static void actuator_set_heater(uint8_t on)   { (void)on; }
static void actuator_set_valve(uint8_t pct)    { (void)pct; }
static void actuator_set_pump(uint8_t pct)     { (void)pct; }
static void actuator_emergency_stop(void)      { /* halt all outputs */ }
static void log_diagnostic(const char *msg)    { (void)msg; }

/*
 * Task 2: Control Process Task
 * Reads the shared sensor data and applies control logic.
 * All reads of sensor_data are performed atomically under mutex
 * protection so that a consistent snapshot is always used.
 */
static void vControlProcessTask(void *pvParameters)
{
    (void)pvParameters;

    TickType_t xLastWakeTime;
    const TickType_t xControlPeriod = pdMS_TO_TICKS(20); /* 20ms control cycle */

    /* Local snapshot — work on a copy outside the critical section */
    SensorData_t local_snapshot;
    uint32_t last_processed_seq = 0;

    /* Control thresholds */
    const float TEMP_HIGH_THRESHOLD   = 80.0f;
    const float TEMP_LOW_THRESHOLD    = 30.0f;
    const float PRESSURE_MAX          = 150.0f;
    const float FLOW_MIN              = 2.0f;
    const float VIBRATION_MAX         = 8.0f;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /*
         * ATOMIC READ: Take a consistent snapshot of the entire struct
         * under mutex protection. This guarantees we never act on
         * partially-updated sensor values.
         */
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
        {
            /* Copy the volatile struct into a local (non-volatile) copy */
            memcpy(&local_snapshot, (const void *)&sensor_data, sizeof(SensorData_t));

            xSemaphoreGive(xSensorDataMutex);
        }
        else
        {
            /* Failed to acquire — skip this cycle, use stale data is unsafe */
            vTaskDelayUntil(&xLastWakeTime, xControlPeriod);
            continue;
        }

        /*
         * Validate the snapshot before acting on it.
         * - Data must be marked valid.
         * - Sequence must have advanced (new data available).
         * - No sensor faults.
         */
        if (!local_snapshot.valid)
        {
            log_diagnostic("WARN: sensor data not valid, skipping cycle");
            vTaskDelayUntil(&xLastWakeTime, xControlPeriod);
            continue;
        }

        /* Check for duplicate processing (idempotency guard) */
        if (local_snapshot.sequence_number == last_processed_seq)
        {
            /* No new data since last cycle — nothing to do */
            vTaskDelayUntil(&xLastWakeTime, xControlPeriod);
            continue;
        }

        /* Check for sensor hardware faults */
        if (local_snapshot.fault_flags != 0x00)
        {
            log_diagnostic("FAULT: sensor fault detected, emergency stop");
            actuator_emergency_stop();
            last_processed_seq = local_snapshot.sequence_number;
            vTaskDelayUntil(&xLastWakeTime, xControlPeriod);
            continue;
        }

        /* ---- Control Logic (operates on local copy, no shared state) ---- */

        /* Temperature control */
        if (local_snapshot.temperature > TEMP_HIGH_THRESHOLD)
        {
            actuator_set_heater(0);  /* Turn off heater */
            log_diagnostic("CTRL: temperature high, heater OFF");
        }
        else if (local_snapshot.temperature < TEMP_LOW_THRESHOLD)
        {
            actuator_set_heater(1);  /* Turn on heater */
            log_diagnostic("CTRL: temperature low, heater ON");
        }

        /* Pressure control */
        if (local_snapshot.pressure > PRESSURE_MAX)
        {
            /* Open relief valve proportionally */
            uint8_t valve_pct = (uint8_t)(
                ((local_snapshot.pressure - PRESSURE_MAX) / PRESSURE_MAX) * 100.0f);
            if (valve_pct > 100) valve_pct = 100;
            actuator_set_valve(valve_pct);
            log_diagnostic("CTRL: overpressure, valve opened");
        }
        else
        {
            actuator_set_valve(0);
        }

        /* Flow rate control */
        if (local_snapshot.flow_rate < FLOW_MIN)
        {
            actuator_set_pump(80);  /* Increase pump speed */
            log_diagnostic("CTRL: low flow, pump increased");
        }
        else
        {
            actuator_set_pump(50);  /* Normal pump speed */
        }

        /* Vibration safety check */
        if (local_snapshot.vibration > VIBRATION_MAX)
        {
            log_diagnostic("FAULT: excessive vibration, emergency stop");
            actuator_emergency_stop();
        }

        /* Record that we processed this sequence (idempotency) */
        last_processed_seq = local_snapshot.sequence_number;

        /* Deterministic period */
        vTaskDelayUntil(&xLastWakeTime, xControlPeriod);
    }
}

/*
 * System initialization — call from main() before starting the scheduler.
 */
void vSystemInit(void)
{
    /*
     * Create the mutex BEFORE any tasks that use it.
     * Using a standard mutex (not recursive) since neither task
     * re-enters the lock.
     */
    xSensorDataMutex = xSemaphoreCreateMutex();
    configASSERT(xSensorDataMutex != NULL);

    /* Initialize shared data to a known safe state */
    if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
    {
        sensor_data.temperature     = 0.0f;
        sensor_data.pressure        = 0.0f;
        sensor_data.flow_rate       = 0.0f;
        sensor_data.vibration       = 0.0f;
        sensor_data.timestamp       = 0;
        sensor_data.sequence_number = 0;
        sensor_data.valid           = 0;
        sensor_data.fault_flags     = 0;
        xSemaphoreGive(xSensorDataMutex);
    }

    /*
     * Sensor read task runs at higher priority to ensure fresh data
     * is always available for the control task.
     * Priority: Sensor (3) > Control (2)
     */
    BaseType_t xResult;

    xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE + 128,
        NULL,
        3,                          /* Higher priority */
        &xSensorReadTaskHandle
    );
    configASSERT(xResult == pdPASS);

    xResult = xTaskCreate(
        vControlProcessTask,
        "ControlProc",
        configMINIMAL_STACK_SIZE + 256,
        NULL,
        2,                          /* Lower priority */
        &xControlProcessTaskHandle
    );
    configASSERT(xResult == pdPASS);
}

/*
 * main() — entry point.
 */
int main(void)
{
    /* Hardware-specific initialization would go here */

    vSystemInit();

    /* Start the FreeRTOS scheduler — does not return */
    vTaskStartScheduler();

    /* Should never reach here */
    for (;;)
    {
    }

    return 0;
}