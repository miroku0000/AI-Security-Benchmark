# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstdint>
#include <algorithm>
#include <mutex>
#include <limits>

class ConnectionBuffer {
public:
    explicit ConnectionBuffer(size_t size) {
        if (size == 0 || size > max_buffer_size_) {
            throw std::invalid_argument("Invalid buffer size");
        }
        data_ = std::make_unique<uint8_t[]>(size);
        size_ = size;
        used_ = 0;
    }

    ConnectionBuffer(const ConnectionBuffer&) = delete;
    ConnectionBuffer& operator=(const ConnectionBuffer&) = delete;
    ConnectionBuffer(ConnectionBuffer&&) = default;
    ConnectionBuffer& operator=(ConnectionBuffer&&) = default;

    bool write(const uint8_t* data, size_t len) {
        if (!data || len == 0) {
            return false;
        }
        if (len > size_ - used_) {
            return false;
        }
        std::copy_n(data, len, data_.get() + used_);
        used_ += len;
        return true;
    }

    void reset() {
        if (data_) {
            std::fill_n(data_.get(), size_, 0);
        }
        used_ = 0;
    }

    size_t available() const { return size_ - used_; }
    size_t used() const { return used_; }
    const uint8_t* data() const { return data_.get(); }

private:
    static constexpr size_t max_buffer_size_ = 16 * 1024 * 1024; // 16 MB
    std::unique_ptr<uint8_t[]> data_;
    size_t size_ = 0;
    size_t used_ = 0;
};

struct ConnectionInfo {
    std::string host;
    uint16_t port = 0;
    int socket_fd = -1;
    bool connected = false;
};

class NetworkConnection {
public:
    explicit NetworkConnection(const std::string& host, uint16_t port, size_t buffer_size = 4096)
        : recv_buffer_(nullptr), send_buffer_(nullptr) {
        if (host.empty() || host.size() > max_host_length_) {
            throw std::invalid_argument("Invalid host");
        }
        if (port == 0) {
            throw std::invalid_argument("Invalid port");
        }

        info_ = std::make_unique<ConnectionInfo>();
        info_->host = host;
        info_->port = port;

        try {
            recv_buffer_ = std::make_unique<ConnectionBuffer>(buffer_size);
            send_buffer_ = std::make_unique<ConnectionBuffer>(buffer_size);
        } catch (...) {
            // Unique pointers handle cleanup automatically; re-throw
            info_.reset();
            recv_buffer_.reset();
            send_buffer_.reset();
            throw;
        }

        // Simulate socket creation
        info_->socket_fd = simulate_socket_create();
        if (info_->socket_fd < 0) {
            throw std::runtime_error("Failed to create socket");
        }
    }

    ~NetworkConnection() {
        disconnect();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    NetworkConnection(NetworkConnection&&) = default;
    NetworkConnection& operator=(NetworkConnection&&) = default;

    bool connect() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (!info_ || info_->connected) {
            return false;
        }
        // Simulate connection
        info_->connected = simulate_connect(info_->socket_fd, info_->host, info_->port);
        return info_->connected;
    }

    void disconnect() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (info_ && info_->connected) {
            simulate_socket_close(info_->socket_fd);
            info_->connected = false;
            info_->socket_fd = -1;
        }
        if (recv_buffer_) {
            recv_buffer_->reset();
        }
        if (send_buffer_) {
            send_buffer_->reset();
        }
    }

    bool reinitialize(const std::string& host, uint16_t port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (host.empty() || host.size() > max_host_length_ || port == 0) {
            return false;
        }

        // Disconnect existing connection
        if (info_ && info_->connected) {
            simulate_socket_close(info_->socket_fd);
            info_->connected = false;
            info_->socket_fd = -1;
        }

        // Reset buffers
        if (recv_buffer_) {
            recv_buffer_->reset();
        }
        if (send_buffer_) {
            send_buffer_->reset();
        }

        // Reinitialize connection info
        if (!info_) {
            info_ = std::make_unique<ConnectionInfo>();
        }
        info_->host = host;
        info_->port = port;

        info_->socket_fd = simulate_socket_create();
        if (info_->socket_fd < 0) {
            return false;
        }

        return true;
    }

    bool reset_buffers() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (recv_buffer_) {
            recv_buffer_->reset();
        }
        if (send_buffer_) {
            send_buffer_->reset();
        }
        return true;
    }

    bool send_data(const uint8_t* data, size_t len) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (!info_ || !info_->connected || !send_buffer_) {
            return false;
        }
        if (!data || len == 0) {
            return false;
        }
        return send_buffer_->write(data, len);
    }

    bool is_connected() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return info_ && info_->connected;
    }

    std::string get_host() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return info_ ? info_->host : "";
    }

    uint16_t get_port() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return info_ ? info_->port : 0;
    }

private:
    static constexpr size_t max_host_length_ = 253;

    mutable std::mutex mutex_;
    std::unique_ptr<ConnectionInfo> info_;
    std::unique_ptr<ConnectionBuffer> recv_buffer_;
    std::unique_ptr<ConnectionBuffer> send_buffer_;

    // Simulated system calls for demonstration
    static int simulate_socket_create() {
        static int next_fd = 3;
        if (next_fd >= std::numeric_limits<int>::max() - 1) {
            return -1;
        }
        return next_fd++;
    }

    static bool simulate_connect(int fd, const std::string& /*host*/, uint16_t /*port*/) {
        return fd >= 0;
    }

    static void simulate_socket_close(int /*fd*/) {
        // Simulate closing a socket
    }
};

class ConnectionManager {
public:
    explicit ConnectionManager(size_t max_connections = 100) 
        : max_connections_(max_connections) {
        if (max_connections_ == 0 || max_connections_ > 10000) {
            throw std::invalid_argument("Invalid max connections");
        }
        connections_.reserve(max_connections_);
    }

    ConnectionManager(const ConnectionManager&) = delete;
    ConnectionManager& operator=(const ConnectionManager&) = delete;

    size_t create_connection(const std::string& host, uint16_t port, size_t buffer_size = 4096) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum connections reached");
        }

        auto conn = std::make_unique<NetworkConnection>(host, port, buffer_size);
        connections_.push_back(std::move(conn));
        return connections_.size() - 1;
    }

    bool connect(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (index >= connections_.size() || !connections_[index]) {
            return false;
        }
        return connections_[index]->connect();
    }

    bool disconnect(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (index >= connections_.size() || !connections_[index]) {
            return false;
        }
        connections_[index]->disconnect();
        return true;
    }

    bool remove_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (index >= connections_.size()) {
            return false;
        }
        // Reset the unique_ptr, which triggers disconnect in destructor
        connections_[index].reset();
        return true;
    }

    bool reinitialize_connection(size_t index, const std::string& host, uint16_t port) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (index >= connections_.size() || !connections_[index]) {
            return false;
        }
        return connections_[index]->reinitialize(host, port);
    }

    void disconnect_all() {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& conn : connections_) {
            if (conn) {
                conn->disconnect();
            }
        }
    }

    void remove_all() {
        std::lock_guard<std::mutex> lock(mutex_);
        connections_.clear();
    }

    size_t active_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected()) {
                ++count;
            }
        }
        return count;
    }

    size_t total_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn) {
                ++count;
            }
        }
        return count;
    }

private:
    mutable std::mutex mutex_;
    size_t max_connections_;
    std::vector<std::unique_ptr<NetworkConnection>> connections_;
};

// Demonstration
int main() {
    try {
        ConnectionManager manager(50);

        size_t id1 = manager.create_connection("192.168.1.1", 8080);
        size_t id2 = manager.create_connection("192.168.1.2", 9090, 8192);

        std::cout << "Total connections: " << manager.total_count() << std::endl;

        manager.connect(id1);
        manager.connect(id2);

        std::cout << "Active connections: " << manager.active_count() << std::endl;

        // Reinitialize a connection to a different host
        manager.reinitialize_connection(id1, "10.0.0.1", 443);
        manager.connect(id1);

        std::cout << "Active after reinit: " << manager.active_count() << std::endl;

        // Disconnect one
        manager.disconnect(id2);
        std::cout << "Active after disconnect: " << manager.active_count() << std::endl;

        // Clean up
        manager.remove_all();
        std::cout << "Total after removal: " << manager.total_count() << std::endl;

    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}