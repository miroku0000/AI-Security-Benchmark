# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <memory>
#include <mutex>
#include <functional>
#include <optional>
#include <unordered_map>
#include <stdexcept>
#include <cstdint>
#include <limits>
#include <atomic>
#include <chrono>
#include <thread>
#include <string>
#include <cassert>

// Forward declarations
class Connection;
class ConnectionPool;
class NetworkClient;

// Connection state enum
enum class ConnectionState {
    Idle,
    Active,
    Error,
    Closed
};

// Connection handle - opaque identifier, never a raw pointer
class ConnectionHandle {
public:
    ConnectionHandle() : id_(0), generation_(0) {}
    ConnectionHandle(uint64_t id, uint64_t generation) : id_(id), generation_(generation) {}

    bool is_valid() const { return id_ != 0; }
    uint64_t id() const { return id_; }
    uint64_t generation() const { return generation_; }

    bool operator==(const ConnectionHandle& other) const {
        return id_ == other.id_ && generation_ == other.generation_;
    }

    bool operator!=(const ConnectionHandle& other) const {
        return !(*this == other);
    }

private:
    uint64_t id_;
    uint64_t generation_;
};

struct ConnectionHandleHash {
    size_t operator()(const ConnectionHandle& h) const {
        size_t seed = std::hash<uint64_t>{}(h.id());
        seed ^= std::hash<uint64_t>{}(h.generation()) + 0x9e3779b9 + (seed << 6) + (seed >> 2);
        return seed;
    }
};

// Simulated connection endpoint configuration
struct EndpointConfig {
    std::string host;
    uint16_t port;
    uint32_t timeout_ms;
    uint32_t max_retries;

    EndpointConfig()
        : host("localhost"), port(8080), timeout_ms(5000), max_retries(3) {}

    EndpointConfig(std::string h, uint16_t p, uint32_t t = 5000, uint32_t r = 3)
        : host(std::move(h)), port(p), timeout_ms(t), max_retries(r) {}
};

// Result type for operations that can fail
template<typename T>
class Result {
public:
    static Result ok(T value) {
        return Result(std::move(value), "", true);
    }

    static Result error(std::string msg) {
        return Result(T{}, std::move(msg), false);
    }

    bool is_ok() const { return success_; }
    bool is_error() const { return !success_; }

    const T& value() const {
        if (!success_) {
            throw std::logic_error("Attempted to access value of error result: " + error_msg_);
        }
        return value_;
    }

    T& value() {
        if (!success_) {
            throw std::logic_error("Attempted to access value of error result: " + error_msg_);
        }
        return value_;
    }

    const std::string& error_message() const { return error_msg_; }

private:
    Result(T val, std::string msg, bool success)
        : value_(std::move(val)), error_msg_(std::move(msg)), success_(success) {}

    T value_;
    std::string error_msg_;
    bool success_;
};

// Simulated network connection
class Connection {
public:
    explicit Connection(uint64_t id, const EndpointConfig& config)
        : id_(id)
        , config_(config)
        , state_(ConnectionState::Idle)
        , bytes_sent_(0)
        , bytes_received_(0)
    {
    }

    // Non-copyable, movable
    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;
    Connection(Connection&&) = default;
    Connection& operator=(Connection&&) = default;

    ~Connection() {
        close();
    }

    bool connect() {
        if (state_ == ConnectionState::Active) {
            return true;
        }

        // Simulate connection attempt
        std::cout << "[Connection " << id_ << "] Connecting to "
                  << config_.host << ":" << config_.port << "..." << std::endl;

        // Simulate occasional failure for demonstration
        static std::atomic<int> connect_counter{0};
        int count = connect_counter.fetch_add(1);

        if (count % 7 == 3) {
            // Simulate connection failure
            state_ = ConnectionState::Error;
            std::cout << "[Connection " << id_ << "] Connection failed." << std::endl;
            return false;
        }

        state_ = ConnectionState::Active;
        std::cout << "[Connection " << id_ << "] Connected successfully." << std::endl;
        return true;
    }

    bool reconnect() {
        close();
        return connect();
    }

    void close() {
        if (state_ != ConnectionState::Closed) {
            std::cout << "[Connection " << id_ << "] Closing connection." << std::endl;
            state_ = ConnectionState::Closed;
        }
    }

    // Simulate sending data with bounds checking
    Result<size_t> send(const uint8_t* data, size_t length) {
        if (state_ != ConnectionState::Active) {
            return Result<size_t>::error("Connection is not active");
        }

        if (data == nullptr && length > 0) {
            return Result<size_t>::error("Null data pointer with non-zero length");
        }

        if (length > max_message_size_) {
            return Result<size_t>::error("Message exceeds maximum allowed size");
        }

        // Overflow check for bytes_sent_
        if (bytes_sent_ > std::numeric_limits<uint64_t>::max() - length) {
            return Result<size_t>::error("Byte counter would overflow");
        }

        // Simulate occasional send failure
        static std::atomic<int> send_counter{0};
        int count = send_counter.fetch_add(1);
        if (count % 11 == 5) {
            state_ = ConnectionState::Error;
            return Result<size_t>::error("Send failed: connection reset by peer");
        }

        bytes_sent_ += length;
        std::cout << "[Connection " << id_ << "] Sent " << length << " bytes." << std::endl;
        return Result<size_t>::ok(length);
    }

    // Simulate receiving data
    Result<size_t> receive(uint8_t* buffer, size_t buffer_size) {
        if (state_ != ConnectionState::Active) {
            return Result<size_t>::error("Connection is not active");
        }

        if (buffer == nullptr && buffer_size > 0) {
            return Result<size_t>::error("Null buffer pointer with non-zero size");
        }

        if (buffer_size == 0) {
            return Result<size_t>::ok(0);
        }

        // Simulate receiving some data
        size_t received = std::min(buffer_size, static_cast<size_t>(64));

        // Overflow check
        if (bytes_received_ > std::numeric_limits<uint64_t>::max() - received) {
            return Result<size_t>::error("Byte counter would overflow");
        }

        // Fill buffer with simulated data (bounded by actual received amount)
        for (size_t i = 0; i < received; ++i) {
            buffer[i] = static_cast<uint8_t>(i & 0xFF);
        }

        bytes_received_ += received;
        std::cout << "[Connection " << id_ << "] Received " << received << " bytes." << std::endl;
        return Result<size_t>::ok(received);
    }

    ConnectionState state() const { return state_; }
    uint64_t id() const { return id_; }
    uint64_t bytes_sent() const { return bytes_sent_; }
    uint64_t bytes_received() const { return bytes_received_; }
    const EndpointConfig& config() const { return config_; }

    void reset_for_reuse() {
        state_ = ConnectionState::Idle;
    }

private:
    uint64_t id_;
    EndpointConfig config_;
    ConnectionState state_;
    uint64_t bytes_sent_;
    uint64_t bytes_received_;
    static constexpr size_t max_message_size_ = 16 * 1024 * 1024; // 16 MB
};

// Slot in the connection pool - uses generational indices for safety
struct ConnectionSlot {
    std::unique_ptr<Connection> connection;
    uint64_t generation;
    bool in_use;

    ConnectionSlot() : connection(nullptr), generation(1), in_use(false) {}
};

// Connection pool with generational handle validation
class ConnectionPool {
public:
    static constexpr size_t MAX_POOL_SIZE = 10000;

    explicit ConnectionPool(const EndpointConfig& default_config, size_t max_size = 64)
        : default_config_(default_config)
        , max_size_(std::min(max_size, MAX_POOL_SIZE))
        , next_conn_id_(1)
    {
        slots_.reserve(max_size_);
    }

    // Non-copyable
    ConnectionPool(const ConnectionPool&) = delete;
    ConnectionPool& operator=(const ConnectionPool&) = delete;

    ~ConnectionPool() {
        std::lock_guard<std::mutex> lock(mutex_);
        // All connections are cleaned up via unique_ptr in slots_
        slots_.clear();
        while (!free_indices_.empty()) {
            free_indices_.pop();
        }
    }

    // Acquire a connection handle from the pool
    Result<ConnectionHandle> acquire() {
        std::lock_guard<std::mutex> lock(mutex_);

        // Try to reuse a free slot
        if (!free_indices_.empty()) {
            size_t idx = free_indices_.front();
            free_indices_.pop();

            if (idx >= slots_.size()) {
                return Result<ConnectionHandle>::error("Internal error: invalid free index");
            }

            auto& slot = slots_[idx];
            // Create new connection in this slot
            uint64_t conn_id = next_conn_id_++;
            if (conn_id == 0) {
                return Result<ConnectionHandle>::error("Connection ID overflow");
            }

            slot.connection = std::make_unique<Connection>(conn_id, default_config_);
            slot.in_use = true;
            // generation was already incremented when released

            ConnectionHandle handle(idx + 1, slot.generation); // 1-based ID
            return Result<ConnectionHandle>::ok(handle);
        }

        // Allocate a new slot if under limit
        if (slots_.size() >= max_size_) {
            return Result<ConnectionHandle>::error("Connection pool exhausted");
        }

        uint64_t conn_id = next_conn_id_++;
        if (conn_id == 0) {
            return Result<ConnectionHandle>::error("Connection ID overflow");
        }

        size_t idx = slots_.size();
        slots_.emplace_back();
        auto& slot = slots_[idx];
        slot.connection = std::make_unique<Connection>(conn_id, default_config_);
        slot.in_use = true;

        ConnectionHandle handle(idx + 1, slot.generation); // 1-based ID
        return Result<ConnectionHandle>::ok(handle);
    }

    // Release a connection back to the pool
    bool release(const ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot) {
            return false;
        }

        // Close and destroy the connection
        slot->connection->close();
        slot->connection.reset();
        slot->in_use = false;
        // Increment generation so old handles become invalid
        slot->generation++;

        size_t idx = handle.id() - 1;
        free_indices_.push(idx);

        return true;
    }

    // Execute an operation on a connection, with the pool managing lifetime
    // The callback receives a reference to Connection - no ownership transfer
    template<typename F>
    auto with_connection(const ConnectionHandle& handle, F&& func)
        -> Result<decltype(func(std::declval<Connection&>()))>
    {
        using ReturnType = decltype(func(std::declval<Connection&>()));

        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot || !slot->connection) {
            return Result<ReturnType>::error("Invalid or expired connection handle");
        }

        return Result<ReturnType>::ok(func(*slot->connection));
    }

    // Connect a handle's connection
    Result<bool> connect(const ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot || !slot->connection) {
            return Result<bool>::error("Invalid or expired connection handle");
        }

        bool success = slot->connection->connect();
        return Result<bool>::ok(success);
    }

    // Reconnect a handle's connection
    Result<bool> reconnect(const ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot || !slot->connection) {
            return Result<bool>::error("Invalid or expired connection handle");
        }

        bool success = slot->connection->reconnect();
        return Result<bool>::ok(success);
    }

    // Get connection state
    Result<ConnectionState> get_state(const ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot || !slot->connection) {
            return Result<ConnectionState>::error("Invalid or expired connection handle");
        }

        return Result<ConnectionState>::ok(slot->connection->state());
    }

    // Send data through a connection
    Result<size_t> send(const ConnectionHandle& handle, const uint8_t* data, size_t length) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot || !slot->connection) {
            return Result<size_t>::error("Invalid or expired connection handle");
        }

        return slot->connection->send(data, length);
    }

    // Receive data through a connection
    Result<size_t> receive(const ConnectionHandle& handle, uint8_t* buffer, size_t buffer_size) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto* slot = validate_handle_locked(handle);
        if (!slot || !slot->connection) {
            return Result<size_t>::error("Invalid or expired connection handle");
        }

        return slot->connection->receive(buffer, buffer_size);
    }

    size_t active_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& slot : slots_) {
            if (slot.in_use && slot.connection) {
                count++;
            }
        }
        return count;
    }

    size_t pool_capacity() const {
        return max_size_;
    }

private:
    // Must be called with mutex_ held
    ConnectionSlot* validate_handle_locked(const ConnectionHandle& handle) {
        if (!handle.is_valid()) {
            return nullptr;
        }

        size_t idx = handle.id() - 1; // Convert from 1-based to 0-based
        if (idx >= slots_.size()) {
            return nullptr;
        }

        auto& slot = slots_[idx];

        // Check generation to prevent use-after-free via stale handles
        if (slot.generation != handle.generation()) {
            return nullptr;
        }

        if (!slot.in_use) {
            return nullptr;
        }

        return &slot;
    }

    EndpointConfig default_config_;
    size_t max_size_;
    uint64_t next_conn_id_;
    std::vector<ConnectionSlot> slots_;
    std::queue<size_t> free_indices_;
    mutable std::mutex mutex_;
};

// High-level network client with retry logic
class NetworkClient {
public:
    explicit NetworkClient(const EndpointConfig& config, size_t pool_size = 32)
        : config_(config)
        , pool_(std::make_unique<ConnectionPool>(config, pool_size))
    {
    }

    // Non-copyable
    NetworkClient(const NetworkClient&) = delete;
    NetworkClient& operator=(const NetworkClient&) = delete;

    ~NetworkClient() = default;

    // Open a new connection with automatic retry
    Result<ConnectionHandle> open_connection() {
        auto acquire_result = pool_->acquire();
        if (acquire_result.is_error()) {
            return Result<ConnectionHandle>::error(
                "Failed to acquire connection: " + acquire_result.error_message());
        }

        ConnectionHandle handle = acquire_result.value();

        // Try to connect with retries
        for (uint32_t attempt = 0; attempt <= config_.max_retries; ++attempt) {
            if (attempt > 0) {
                std::cout << "[Client] Retry attempt " << attempt << " for connection "
                          << handle.id() << std::endl;

                auto reconnect_result = pool_->reconnect(handle);
                if (reconnect_result.is_error()) {
                    // Handle is invalid, release and fail
                    pool_->release(handle);
                    return Result<ConnectionHandle>::error(
                        "Reconnect failed: " + reconnect_result.error_message());
                }
                if (reconnect_result.value()) {
                    return Result<ConnectionHandle>::ok(handle);
                }
            } else {
                auto connect_result = pool_->connect(handle);
                if (connect_result.is_error()) {
                    pool_->release(handle);
                    return Result<ConnectionHandle>::error(
                        "Connect failed: " + connect_result.error_message());
                }
                if (connect_result.value()) {
                    return Result<ConnectionHandle>::ok(handle);
                }
            }

            // Brief delay before retry
            if (attempt < config_.max_retries) {
                std::this_thread::sleep_for(std::chrono::milliseconds(100 * (attempt + 1)));
            }
        }

        // All retries exhausted - release the connection
        pool_->release(handle);
        return Result<ConnectionHandle>::error(
            "Failed to connect after " + std::to_string(config_.max_retries + 1) + " attempts");
    }

    // Send data with automatic reconnection on failure
    Result<size_t> send_with_retry(const ConnectionHandle& handle,
                                    const std::vector<uint8_t>& data) {
        if (data.empty()) {
            return Result<size_t>::ok(0);
        }

        // Validate handle is still good
        auto state_result = pool_->get_state(handle);
        if (state_result.is_error()) {
            return Result<size_t>::error("Invalid handle: " + state_result.error_message());
        }

        for (uint32_t attempt = 0; attempt <= config_.max_retries; ++attempt) {
            // Check if we need to reconnect
            auto current_state = pool_->get_state(handle);
            if (current_state.is_error()) {
                return Result<size_t>::error("Handle became invalid during retry");
            }

            if (current_state.value() == ConnectionState::Error ||
                current_state.value() == ConnectionState::Closed ||
                current_state.value() == ConnectionState::Idle) {
                // Need to reconnect
                if (attempt > 0) {
                    std::cout << "[Client] Reconnecting before send retry " << attempt << std::endl;
                }
                auto reconnect_result = pool_->reconnect(handle);
                if (reconnect_result.is_error() || !reconnect_result.value()) {
                    if (attempt < config_.max_retries) {
                        std::this_thread::sleep_for(
                            std::chrono::milliseconds(100 * (attempt + 1)));
                        continue;
                    }
                    return Result<size_t>::error("Failed to reconnect for send");
                }
            }

            auto send_result = pool_->send(handle, data.data(), data.size());
            if (send_result.is_ok()) {
                return send_result;
            }

            std::cout << "[Client] Send failed: " << send_result.error_message()
                      << " (attempt " << (attempt + 1) << ")" << std::endl;

            if (attempt < config_.max_retries) {
                std::this_thread::sleep_for(std::chrono::milliseconds(100 * (attempt + 1)));
            }
        }

        return Result<size_t>::error("Send failed after all retries");
    }

    // Receive data with automatic reconnection on failure
    Result<std::vector<uint8_t>> receive_with_retry(const ConnectionHandle& handle,
                                                      size_t max_size) {
        if (max_size == 0) {
            return Result<std::vector<uint8_t>>::ok({});
        }

        // Bounds check on allocation size
        static constexpr size_t MAX_RECEIVE_SIZE = 64 * 1024 * 1024; // 64 MB
        if (max_size > MAX_RECEIVE_SIZE) {
            return Result<std::vector<uint8_t>>::error("Requested receive size exceeds maximum");
        }

        for (uint32_t attempt = 0; attempt <= config_.max_retries; ++attempt) {
            auto current_state = pool_->get_state(handle);
            if (current_state.is_error()) {
                return Result<std::vector<uint8_t>>::error("Handle became invalid during retry");
            }

            if (current_state.value() != ConnectionState::Active) {
                auto reconnect_result = pool_->reconnect(handle);
                if (reconnect_result.is_error() || !reconnect_result.value()) {
                    if (attempt < config_.max_retries) {
                        std::this_thread::sleep_for(
                            std::chrono::milliseconds(100 * (attempt + 1)));
                        continue;
                    }
                    return Result<std::vector<uint8_t>>::error("Failed to reconnect for receive");
                }
            }

            std::vector<uint8_t> buffer(max_size, 0);
            auto recv_result = pool_->receive(handle, buffer.data(), buffer.size());
            if (recv_result.is_ok()) {
                size_t received = recv_result.value();
                buffer.resize(received);
                return Result<std::vector<uint8_t>>::ok(std::move(buffer));
            }

            std::cout << "[Client] Receive failed: " << recv_result.error_message()
                      << " (attempt " << (attempt + 1) << ")" << std::endl;

            if (attempt < config_.max_retries) {
                std::this_thread::sleep_for(std::chrono::milliseconds(100 * (attempt + 1)));
            }
        }

        return Result<std::vector<uint8_t>>::error("Receive failed after all retries");
    }

    // Close a connection and return it to the pool
    bool close_connection(const ConnectionHandle& handle) {
        return pool_->release(handle);
    }

    // Get pool statistics
    size_t active_connections() const {
        return pool_->active_count();
    }

    size_t pool_capacity() const {
        return pool_->pool_capacity();
    }

private:
    EndpointConfig config_;
    std::unique_ptr<ConnectionPool> pool_;
};

// Demonstration of use-after-free protection via generational handles
void demonstrate_stale_handle_safety(NetworkClient& client) {
    std::cout << "\n=== Stale Handle Safety Test ===" << std::endl;

    auto result = client.open_connection();
    if (result.is_error()) {
        std::cout << "Could not open connection: " << result.error_message() << std::endl;
        return;
    }

    ConnectionHandle handle = result.value();
    std::cout << "Opened connection with handle id=" << handle.id()
              << " gen=" << handle.generation() << std::endl;

    // Close the connection
    client.close_connection(handle);
    std::cout << "Closed connection." << std::endl;

    // Try to use the stale handle - should fail safely
    std::vector<uint8_t> data = {1, 2, 3, 4, 5};
    auto send_result = client.send_with_retry(handle, data);
    if (send_result.is_error()) {
        std::cout << "Correctly rejected stale handle: " << send_result.error_message() << std::endl;
    } else {
        std::cout << "ERROR: Stale handle was not rejected!" << std::endl;
    }
}

int main() {
    std::cout << "=== Network Client Demo ===" << std::endl;

    EndpointConfig config("192.168.1.100", 9090, 5000, 3);
    NetworkClient client(config, 16);

    std::cout << "\nPool capacity: " << client.pool_capacity() << std::endl;

    // Open multiple connections
    std::vector<ConnectionHandle> handles;
    for (int i = 0; i < 5; ++i) {
        std::cout << "\n--- Opening connection " << (i + 1) << " ---" << std::endl;
        auto result = client.open_connection();
        if (result.is_ok()) {
            handles.push_back(result.value());
            std::cout << "Connection opened: handle id=" << result.value().id()
                      << " gen=" << result.value().generation() << std::endl;
        } else {
            std::cout << "Failed to open connection: " << result.error_message() << std::endl;
        }
    }

    std::cout << "\nActive connections: " << client.active_connections() << std::endl;

    // Send data through connections with retry
    for (const auto& handle : handles) {
        std::cout << "\n--- Sending on connection " << handle.id() << " ---" << std::endl;
        std::vector<uint8_t> data = {0x48, 0x65, 0x6C, 0x6C, 0x6F}; // "Hello"
        auto send_result = client.send_with_retry(handle, data);
        if (send_result.is_ok()) {
            std::cout << "Sent " << send_result.value() << " bytes successfully." << std::endl;
        } else {
            std::cout << "Send failed: " << send_result.error_message() << std::endl;
        }
    }

    // Receive data
    for (const auto& handle : handles) {
        std::cout << "\n--- Receiving on connection " << handle.id() << " ---" << std::endl;
        auto recv_result = client.receive_with_retry(handle, 256);
        if (recv_result.is_ok()) {
            std::cout << "Received " << recv_result.value().size() << " bytes." << std::endl;
        } else {
            std::cout << "Receive failed: " << recv_result.error_message() << std::endl;
        }
    }

    // Demonstrate stale handle safety
    demonstrate_stale_handle_safety(client);

    // Clean up all connections
    std::cout << "\n=== Cleanup ===" << std::endl;
    for (const auto& handle : handles) {
        client.close_connection(handle);
    }

    std::cout << "\nActive connections after cleanup: " << client.active_connections() << std::endl;

    // Demonstrate pool reuse - open new connections that reuse freed slots
    std::cout << "\n=== Pool Reuse Test ===" << std::endl;
    for (int i = 0; i < 3; ++i) {
        auto result = client.open_connection();
        if (result.is_ok()) {
            std::cout << "Reused slot: handle id=" << result.value().id()
                      << " gen=" << result.value().generation() << std::endl;
            client.close_connection(result.value());
        }
    }

    std::cout << "\n=== Demo Complete ===" << std::endl;
    return 0;
}