# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <cstddef>
#include <cstring>
#include <string>
#include <vector>
#include <stdexcept>
#include <limits>
#include <iostream>

// Safe structure to hold the concatenated argument string
struct ParsedArgs {
    std::vector<char> buffer; // Owns the memory, automatic cleanup
    size_t length;            // Actual length of the concatenated string (excluding null terminator)

    // Returns a const pointer to the internal buffer for read-only access
    const char* c_str() const {
        if (buffer.empty()) {
            return "";
        }
        return buffer.data();
    }
};

// Parses command-line arguments and concatenates them into a single string for logging.
// Returns a ParsedArgs struct that owns the resulting buffer.
// Throws std::invalid_argument if argc/argv are invalid.
// Throws std::overflow_error if total size would overflow.
// Throws std::length_error if total size exceeds a reasonable maximum.
ParsedArgs parse_and_concatenate_args(int argc, char* argv[]) {
    // Validate inputs
    if (argc < 0) {
        throw std::invalid_argument("argc must be non-negative");
    }
    if (argc > 0 && argv == nullptr) {
        throw std::invalid_argument("argv must not be null when argc > 0");
    }

    ParsedArgs result;
    result.length = 0;

    if (argc == 0) {
        result.buffer.push_back('\0');
        return result;
    }

    // Define a reasonable maximum to prevent excessive allocation
    constexpr size_t MAX_TOTAL_SIZE = 1024 * 1024; // 1 MB limit

    // First pass: calculate total required size with overflow checks
    size_t total_size = 0;
    std::vector<size_t> arg_lengths(static_cast<size_t>(argc));

    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            throw std::invalid_argument(
                std::string("argv[") + std::to_string(i) + "] is null");
        }

        size_t arg_len = strnlen(argv[i], MAX_TOTAL_SIZE + 1);
        if (arg_len > MAX_TOTAL_SIZE) {
            throw std::length_error(
                std::string("Argument ") + std::to_string(i) + " exceeds maximum allowed length");
        }

        arg_lengths[static_cast<size_t>(i)] = arg_len;

        // Check for overflow before adding
        if (total_size > std::numeric_limits<size_t>::max() - arg_len) {
            throw std::overflow_error("Total argument size would overflow");
        }
        total_size += arg_len;

        // Add space for separator (space between arguments)
        if (i < argc - 1) {
            if (total_size > std::numeric_limits<size_t>::max() - 1) {
                throw std::overflow_error("Total argument size would overflow with separators");
            }
            total_size += 1; // for the space separator
        }
    }

    // Check against maximum allowed size
    if (total_size > MAX_TOTAL_SIZE) {
        throw std::length_error("Concatenated arguments exceed maximum allowed size of " +
                                std::to_string(MAX_TOTAL_SIZE) + " bytes");
    }

    // Check for null terminator space
    if (total_size > std::numeric_limits<size_t>::max() - 1) {
        throw std::overflow_error("Total size with null terminator would overflow");
    }

    // Allocate buffer (vector handles allocation failure via std::bad_alloc)
    result.buffer.resize(total_size + 1, '\0');
    result.length = total_size;

    // Second pass: safely copy arguments into the buffer
    size_t offset = 0;
    for (int i = 0; i < argc; ++i) {
        size_t arg_len = arg_lengths[static_cast<size_t>(i)];

        // Bounds check before copy (defensive, should always hold given first pass)
        if (offset + arg_len > total_size) {
            throw std::overflow_error("Internal error: offset exceeded calculated total size");
        }

        std::memcpy(result.buffer.data() + offset, argv[i], arg_len);
        offset += arg_len;

        // Add space separator between arguments
        if (i < argc - 1) {
            if (offset >= total_size + 1) {
                throw std::overflow_error("Internal error: separator offset out of bounds");
            }
            result.buffer[offset] = ' ';
            offset += 1;
        }
    }

    // Ensure null termination
    result.buffer[offset] = '\0';

    return result;
}

// Convenience function that returns a std::string instead
std::string parse_args_to_string(int argc, char* argv[]) {
    ParsedArgs parsed = parse_and_concatenate_args(argc, argv);
    return std::string(parsed.c_str(), parsed.length);
}

// Example / demonstration
int main(int argc, char* argv[]) {
    try {
        ParsedArgs parsed = parse_and_concatenate_args(argc, argv);
        std::cout << "Parsed command line (" << parsed.length << " chars): "
                  << parsed.c_str() << std::endl;

        // Also demonstrate the string version
        std::string log_line = parse_args_to_string(argc, argv);
        std::cout << "Log entry: [" << log_line << "]" << std::endl;

    } catch (const std::exception& e) {
        std::cerr << "Error parsing arguments: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}