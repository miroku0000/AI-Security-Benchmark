# Generated by ollama (codellama)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions_.push_back(std::move(session));
    }

    std::unique_ptr<Session> removeSession(size_t index) {
        if (index >= sessions_.size()) {
            return nullptr;
        }
        auto session = std::move(sessions_[index]);
        sessions_.erase(sessions_.begin() + index);
        return session;
    }

    Session& getSession(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Invalid session index");
        }
        return *sessions_[index];
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
};