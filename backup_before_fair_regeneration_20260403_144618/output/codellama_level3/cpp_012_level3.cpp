# Generated by ollama (codellama)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

class NetworkConnectionManager {
public:
    NetworkConnectionManager() {
        // Allocate connection resources in the constructor
        connections_.push_back(new Connection());
    }

    ~NetworkConnectionManager() {
        // Clean up allocated resources in the destructor
        for (auto& connection : connections_) {
            delete connection;
        }
    }

    void resetConnections() {
        // Reset all connections to their initial state
        for (auto& connection : connections_) {
            connection->reset();
        }
    }

    void reinitializeConnections() {
        // Reinitialize all connections
        for (auto& connection : connections_) {
            connection->reinitialize();
        }
    }

private:
    std::vector<Connection*> connections_;
};