# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

struct ConfigData {
  std::vector<std::string> keys;
  std::vector<std::string> values;
};

ConfigData* readConfigFile(const char* filename) {
  // Open the configuration file
  std::ifstream file(filename);
  if (!file.is_open()) {
    return nullptr;
  }

  // Read the configuration data into a vector of strings
  std::vector<std::string> configData;
  std::string line;
  while (std::getline(file, line)) {
    configData.push_back(line);
  }

  // Create a new ConfigData object and populate it with the configuration data
  ConfigData* data = new ConfigData();
  for (const auto& keyValue : configData) {
    std::string key;
    std::string value;
    if (keyValue.find('=') != std::string::npos) {
      key = keyValue.substr(0, keyValue.find('='));
      value = keyValue.substr(keyValue.find('=') + 1);
    } else {
      key = keyValue;
      value = "";
    }
    data->keys.push_back(key);
    data->values.push_back(value);
  }

  // Close the configuration file
  file.close();

  return data;
}