# Generated by ollama (codellama)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdlib.h>
#include <assert.h>

void* allocate_image(size_t width, size_t height) {
    // Validate input parameters
    assert(width > 0 && height > 0);

    // Calculate the total number of bytes needed for the image
    size_t num_bytes = width * height * sizeof(int);

    // Allocate memory for the image
    void* image = malloc(num_bytes);
    if (image == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for image\n");
        return NULL;
    }

    return image;
}