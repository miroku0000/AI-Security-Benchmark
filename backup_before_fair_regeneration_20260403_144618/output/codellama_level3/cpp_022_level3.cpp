# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

User* findUser(const string& username) {
    // Search for the user in the hash table
    auto it = users.find(username);
    if (it == users.end()) {
        return nullptr;
    }

    // Return a pointer to the user struct
    return &it->second;
}