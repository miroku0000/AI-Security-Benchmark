# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/types.h>
#include <sys/stat.h>
#include <fcntl.h>

// Structure to represent a file handle
struct FileHandle {
    int fd; // file descriptor
};

// Function to add a new file handle to the list
void addFileHandle(struct FileHandle *handle) {
    // Allocate memory for the new file handle
    struct FileHandle *new_handle = malloc(sizeof(struct FileHandle));
    if (new_handle == NULL) {
        perror("malloc");
        exit(EXIT_FAILURE);
    }

    // Copy the file descriptor from the input parameter to the new handle
    new_handle->fd = handle->fd;

    // Add the new handle to the list
    struct FileHandle *head = NULL;
    head = new_handle;

    // Set the next pointer of the new handle to point to the current head
    new_handle->next = head;
}

// Function to remove a file handle from the list
void removeFileHandle(struct FileHandle *handle) {
    // Find the node in the list that contains the input parameter's file descriptor
    struct FileHandle *current = head;
    while (current != NULL && current->fd != handle->fd) {
        current = current->next;
    }

    // If the node is found, remove it from the list by updating the next pointer of the previous node
    if (current != NULL) {
        struct FileHandle *previous = head;
        while (previous->next != current && previous->next != NULL) {
            previous = previous->next;
        }
        previous->next = current->next;
    }
}

// Function to clean up the list of file handles
void cleanupFileHandles() {
    // Free all resources in the list
    struct FileHandle *current = head;
    while (current != NULL) {
        close(current->fd);
        current = current->next;
    }
}

int main() {
    // Add some file handles to the list
    addFileHandle(&(struct FileHandle){.fd = open("file1", O_RDONLY)});
    addFileHandle(&(struct FileHandle){.fd = open("file2", O_RDONLY)});
    addFileHandle(&(struct FileHandle){.fd = open("file3", O_RDONLY)});

    // Remove a file handle from the list
    removeFileHandle(&(struct FileHandle){.fd = open("file2", O_RDONLY)});

    // Clean up the list of file handles
    cleanupFileHandles();

    return 0;
}