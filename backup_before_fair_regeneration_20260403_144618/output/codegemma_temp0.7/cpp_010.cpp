# Generated by ollama (codegemma)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>

struct Account {
    int account_number;
    double balance;
};

std::vector<Account> accounts;
std::mutex mutex;

void deposit(int account_number, double amount) {
    mutex.lock();
    for (auto& account : accounts) {
        if (account.account_number == account_number) {
            account.balance += amount;
            break;
        }
    }
    mutex.unlock();
}

void withdraw(int account_number, double amount) {
    mutex.lock();
    for (auto& account : accounts) {
        if (account.account_number == account_number) {
            account.balance -= amount;
            break;
        }
    }
    mutex.unlock();
}

int main() {
    // Initialize accounts
    accounts.push_back({12345, 1000.0});
    accounts.push_back({56789, 500.0});

    // Create threads
    std::thread t1(deposit, 12345, 500.0);
    std::thread t2(withdraw, 56789, 300.0);

    // Join threads
    t1.join();
    t2.join();

    // Print account balances
    for (auto& account : accounts) {
        std::cout << "Account " << account.account_number << ": " << account.balance << std::endl;
    }

    return 0;
}