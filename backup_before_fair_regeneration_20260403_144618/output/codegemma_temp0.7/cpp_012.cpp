# Generated by ollama (codegemma)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <memory>
#include <vector>

class NetworkManager {
 public:
  NetworkManager() { AllocateResources(); }
  ~NetworkManager() { CleanupResources(); }

  void ResetConnection() {
    ReleaseResources();
    AllocateResources();
  }

  void ReinitializeConnection() {
    CleanupResources();
    AllocateResources();
  }

 private:
  void AllocateResources() {
    // Logic to allocate connection resources
  }

  void ReleaseResources() {
    // Logic to release connection resources
  }

  void CleanupResources() {
    // Logic to cleanup resources in error handling paths
  }

  std::vector<std::unique_ptr<Connection>> connections_;
};