# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseArguments(int argc, char* argv[], char* result) {
    std::string concat;
    for (int i = 1; i < argc; ++i) {
        concat += argv[i];
        if (i != argc - 1) {
            concat += " ";
        }
    }
    strncpy(result, concat.c_str(), sizeof(char)*concat.size());
}