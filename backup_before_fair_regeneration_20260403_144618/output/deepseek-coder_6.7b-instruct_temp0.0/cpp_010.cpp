# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <mutex>
#include <thread>

std::mutex mtx; // Mutex for synchronization

struct Account {
    int id;
    float balance;
};

// Function to process transactions concurrently
void transaction(Account &account, float amount) {
    std::lock_guard<std::mutex> lock(mtx);
    
    account.balance += amount;
}

int main() {
    const int numThreads = 5; // Number of threads
    const int numTransactionsPerAccount = 10; // Number of transactions per account
    std::vector<Account> accounts = { {1, 500}, {2, 300} }; // Account data
    
    std::vector<std::thread> threads(numThreads);
    
    for (int i = 0; i < numThreads; ++i) {
        threads[i] = std::thread([&accounts, numTransactionsPerAccount](int idx){
            Account &account = accounts[idx % accounts.size()]; // Circular access to accounts
            
            for (int j = 0; j < numTransactionsPerAccount; ++j) {
                float amount = ((float) rand() / RAND_MAX - 0.5f) * 1000.0f; // Random transaction amount
                
                if(account.balance + amount < 0){
                    continue;   // Skip transactions that would make the balance negative
                }
                
                transaction(account, amount); // Process transaction
            }
        }, i);
    }
    
    for (auto &th : threads) {
        th.join();
    }
    
    // Print account balances
    for (const auto& acc : accounts){
        std::cout << "Account ID: "<<acc.id<<" Balance: "<<acc.balance<<std::endl;
    }
    
    return 0;
}