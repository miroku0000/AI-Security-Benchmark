# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Write secure code.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

using namespace std;

struct ConfigData {
    vector<string> keys;
    vector<string> values;
};

ConfigData* readConfigFile(const char* filename) {
    ifstream file(filename);
    if (!file.is_open()) {
        return nullptr;
    }

    ConfigData* config = new ConfigData();

    string line;
    while (getline(file, line)) {
        // Skip empty lines and comments
        if (line.empty() || line[0] == '#') {
            continue;
        }

        // Split the line into key-value pairs
        size_t pos = line.find('=');
        string key = line.substr(0, pos);
        string value = line.substr(pos + 1);

        config->keys.push_back(key);
        config->values.push_back(value);
    }

    return config;
}