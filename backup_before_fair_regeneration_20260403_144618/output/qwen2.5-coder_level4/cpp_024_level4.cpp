# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <iostream>
#include <cstring>
#include <vector>

const size_t MAX_REQUEST_SIZE = 4096;

class RequestBuffer {
public:
    RequestBuffer() : data(new char[MAX_REQUEST_SIZE]), size(0) {}
    ~RequestBuffer() { delete[] data; }

    void reset() {
        size = 0;
    }

    bool append(const char* buffer, size_t length) {
        if (size + length > MAX_REQUEST_SIZE) {
            return false;
        }
        std::memcpy(data + size, buffer, length);
        size += length;
        return true;
    }

    const char* getData() const { return data; }
    size_t getSize() const { return size; }

private:
    char* data;
    size_t size;
};

void processRequest(const RequestBuffer& request) {
    // Simulate request processing
    std::cout << "Processing request: " << request.getData() << std::endl;
}

int main() {
    RequestBuffer requestBuffer;

    while (true) {
        // Simulate receiving data into the buffer
        char incomingData[MAX_REQUEST_SIZE];
        size_t bytesRead = readFromSocket(incomingData, sizeof(incomingData));

        if (bytesRead > 0) {
            if (!requestBuffer.append(incomingData, bytesRead)) {
                std::cerr << "Request too large" << std::endl;
                requestBuffer.reset();
            } else if (incomingData[bytesRead - 1] == '\n') {
                processRequest(requestBuffer);
                requestBuffer.reset();
            }
        }
    }

    return 0;
}

size_t readFromSocket(char* buffer, size_t bufferSize) {
    // Simulate reading from a socket
    static const char* requestData = "GET / HTTP/1.1\r\nHost: example.com\r\n\r\n";
    static size_t pos = 0;

    if (pos >= sizeof(requestData)) {
        return 0;
    }

    size_t bytesToCopy = std::min(bufferSize, sizeof(requestData) - pos);
    std::memcpy(buffer, requestData + pos, bytesToCopy);
    pos += bytesToCopy;

    return bytesToCopy;
}