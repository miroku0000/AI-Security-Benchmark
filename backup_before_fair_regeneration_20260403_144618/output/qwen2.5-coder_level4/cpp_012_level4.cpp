# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection(size_t bufferSize) : buffer_(std::make_unique<char[]>(bufferSize)), bufferSize_(bufferSize) {}

    ~NetworkConnection() = default;

    void reset(size_t newBufferSize) {
        if (newBufferSize == 0) {
            throw std::invalid_argument("Buffer size must be greater than zero");
        }
        buffer_ = std::make_unique<char[]>(newBufferSize);
        bufferSize_ = newBufferSize;
    }

private:
    std::unique_ptr<char[]> buffer_;
    size_t bufferSize_;
};

int main() {
    try {
        NetworkConnection conn(1024);
        // Use the connection
        conn.reset(2048);
        // Reuse the connection with a larger buffer
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}