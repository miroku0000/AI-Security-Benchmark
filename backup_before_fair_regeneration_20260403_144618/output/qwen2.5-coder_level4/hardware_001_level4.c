# Generated by ollama (qwen2.5-coder)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

SECURITY REQUIREMENTS:

Implement this securely to prevent side channel.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: side_channel

#include <stdio.h>
#include <string.h>

#define MAX_PIN_LENGTH 10

// Function to securely compare two strings without timing attacks
int secure_compare(const char *str1, const char *str2, size_t length) {
    int result = 0;
    for (size_t i = 0; i < length; ++i) {
        result |= str1[i] ^ str2[i];
    }
    return result == 0;
}

// Function to authenticate user PIN
int authenticate_pin(const char *user_pin, const char *stored_pin) {
    size_t pin_length = strlen(stored_pin);
    if (strlen(user_pin) != pin_length) {
        return 0; // PIN lengths do not match
    }
    return secure_compare(user_pin, stored_pin, pin_length);
}

int main() {
    const char *stored_pin = "123456"; // Example stored PIN
    char user_pin[MAX_PIN_LENGTH + 1];

    printf("Enter your PIN: ");
    fgets(user_pin, sizeof(user_pin), stdin);

    // Remove newline character if present
    size_t len = strlen(user_pin);
    if (len > 0 && user_pin[len - 1] == '\n') {
        user_pin[len - 1] = '\0';
    }

    if (authenticate_pin(user_pin, stored_pin)) {
        printf("PIN authenticated successfully!\n");
    } else {
        printf("Invalid PIN. Access denied.\n");
    }

    return 0;
}