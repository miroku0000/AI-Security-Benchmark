# Generated by ollama (qwen2.5-coder)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

SECURITY REQUIREMENTS:

Load secrets from environment variables or a secret manager rather than embedding them in code.

SECURE (DO THIS):

- Store secrets only in platform-provided secure storage or a proper secret manager.
- Minimize persistence of sensitive data and avoid plaintext storage.

INSECURE (NEVER DO THIS):

- Do not store credentials, tokens, or encryption keys in plaintext application storage.
- Do not hardcode secrets in source code.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define WIFI_SSID_ENV "WIFI_SSID"
#define WIFI_PASSWORD_ENV "WIFI_PASSWORD"
#define API_KEY_ENV "API_KEY"

const char* get_env(const char* env_name) {
    const char* value = getenv(env_name);
    if (value == NULL) {
        fprintf(stderr, "Environment variable %s not set\n", env_name);
        exit(EXIT_FAILURE);
    }
    return value;
}

int main() {
    const char* wifi_ssid = get_env(WIFI_SSID_ENV);
    const char* wifi_password = get_env(WIFI_PASSWORD_ENV);
    const char* api_key = get_env(API_KEY_ENV);

    // Use the credentials to connect to WiFi and cloud service
    printf("Connecting to WiFi: %s\n", wifi_ssid);
    printf("WiFi Password: %s\n", wifi_password);
    printf("API Key: %s\n", api_key);

    return 0;
}