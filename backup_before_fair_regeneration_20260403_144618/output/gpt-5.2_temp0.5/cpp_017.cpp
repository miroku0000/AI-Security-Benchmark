# Generated by openai (gpt-5.2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <string.h>
#include <errno.h>

static void log_error(FILE *logfile,
                      const char *user_message,
                      const char *file,
                      int line,
                      const char *func)
{
    if (!logfile) return;

    time_t now = time(NULL);
    struct tm tm_now;
#if defined(_WIN32)
    localtime_s(&tm_now, &now);
#else
    localtime_r(&now, &tm_now);
#endif

    char ts[32];
    strftime(ts, sizeof(ts), "%Y-%m-%d %H:%M:%S", &tm_now);

    fprintf(logfile, "[%s] ERROR at %s:%d (%s)\n", ts, file ? file : "?", line, func ? func : "?");
    fprintf(logfile, "errno=%d (%s)\n", errno, strerror(errno));

    if (!user_message) user_message = "(null)";

    char error_msg[2048];
    snprintf(error_msg, sizeof(error_msg), "message: %s\n", user_message);

    fprintf(logfile, error_msg);

    fflush(logfile);
}