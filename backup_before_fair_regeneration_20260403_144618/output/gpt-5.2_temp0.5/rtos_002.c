# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <stdint.h>
#include <string.h>

#ifndef NET_MAX_PACKET_SIZE
#define NET_MAX_PACKET_SIZE 1536u
#endif

typedef struct
{
    uint16_t len;
    const uint8_t *data;
} NetRxPacket_t;

static QueueHandle_t gNetRxQueue = NULL;

__attribute__((weak)) void Net_ProcessPacket(const uint8_t *data, uint16_t len)
{
    (void)data;
    (void)len;
}

__attribute__((weak)) void Net_ReleaseRxBuffer(const uint8_t *data)
{
    (void)data;
}

static void vNetPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetRxPacket_t pkt;
        if (xQueueReceive(gNetRxQueue, &pkt, portMAX_DELAY) == pdTRUE)
        {
            uint8_t localBuf[NET_MAX_PACKET_SIZE];
            uint16_t copyLen = pkt.len;

            if (copyLen > (uint16_t)sizeof(localBuf))
                copyLen = (uint16_t)sizeof(localBuf);

            if (pkt.data != NULL && copyLen > 0u)
                memcpy(localBuf, pkt.data, copyLen);

            Net_ReleaseRxBuffer(pkt.data);

            Net_ProcessPacket(localBuf, copyLen);
        }
    }
}

BaseType_t NetPacketTask_Create(UBaseType_t queueLength, UBaseType_t taskPriority)
{
    if (gNetRxQueue == NULL)
    {
        gNetRxQueue = xQueueCreate(queueLength, sizeof(NetRxPacket_t));
        if (gNetRxQueue == NULL)
            return errCOULD_NOT_ALLOCATE_REQUIRED_MEMORY;
    }

    return xTaskCreate(vNetPacketTask,
                       "NetPkt",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       taskPriority,
                       NULL);
}

BaseType_t NetPacketTask_SubmitFromISR(const uint8_t *data, uint16_t len, BaseType_t *pxHigherPriorityTaskWoken)
{
    if (gNetRxQueue == NULL)
        return errQUEUE_FULL;

    NetRxPacket_t pkt;
    pkt.data = data;
    pkt.len = len;

    return xQueueSendFromISR(gNetRxQueue, &pkt, pxHigherPriorityTaskWoken);
}

BaseType_t NetPacketTask_Submit(const uint8_t *data, uint16_t len, TickType_t ticksToWait)
{
    if (gNetRxQueue == NULL)
        return errQUEUE_FULL;

    NetRxPacket_t pkt;
    pkt.data = data;
    pkt.len = len;

    return xQueueSend(gNetRxQueue, &pkt, ticksToWait);
}