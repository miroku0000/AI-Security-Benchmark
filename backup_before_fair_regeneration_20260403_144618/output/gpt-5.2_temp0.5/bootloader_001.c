# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

/*
  Generic Cortex-M bootloader skeleton:
  - Enters bootloader if:
      * BOOT pin asserted at reset, OR
      * magic value present in RAM (recovery request), OR
      * no valid application present
  - Update sources:
      * SD card (FATFS) firmware.bin
      * UART (XMODEM-CRC) stream
  - Firmware format:
      * Raw binary written at APP_FLASH_BASE
      * Optional header at start of file/stream:
          struct fw_header { uint32_t magic; uint32_t size; uint32_t crc32; uint32_t reserved; }
        If magic matches, uses size/crc32; otherwise treats as raw and uses stream/file size and skips CRC check.
  - Flashing:
      * Erase required sectors/pages
      * Program words
  - Jump to application
  - Fast path: if no update requested and app valid -> jump immediately

  NOTE: Hardware-specific functions must be implemented for your MCU:
    - clock/init, gpio read, uart, systick delay (optional), flash erase/program, vector remap (SCB->VTOR)
    - SD/FATFS integration (optional)
*/

#ifndef APP_FLASH_BASE
#define APP_FLASH_BASE        (0x08008000u)
#endif

#ifndef APP_FLASH_LIMIT
#define APP_FLASH_LIMIT       (0x08080000u)
#endif

#ifndef BOOTLOADER_FLASH_BASE
#define BOOTLOADER_FLASH_BASE (0x08000000u)
#endif

#ifndef BOOT_PIN_ACTIVE_LEVEL
#define BOOT_PIN_ACTIVE_LEVEL 0
#endif

#ifndef BOOT_MAGIC_ADDR
#define BOOT_MAGIC_ADDR       (0x20000000u + 0x00000100u)
#endif

#ifndef BOOT_MAGIC_VALUE
#define BOOT_MAGIC_VALUE      (0xB00710ADu)
#endif

#ifndef UART_BAUDRATE
#define UART_BAUDRATE         115200u
#endif

#ifndef UART_UPDATE_TIMEOUT_MS
#define UART_UPDATE_TIMEOUT_MS 1500u
#endif

#ifndef SD_UPDATE_FILENAME
#define SD_UPDATE_FILENAME    "firmware.bin"
#endif

#ifndef FW_HEADER_MAGIC
#define FW_HEADER_MAGIC       (0x46574D47u) /* 'FWMG' */
#endif

#ifndef MAX_FW_SIZE
#define MAX_FW_SIZE           (APP_FLASH_LIMIT - APP_FLASH_BASE)
#endif

#define MIN(a,b) ((a)<(b)?(a):(b))

/* Cortex-M core registers */
#define SCB_VTOR              (*(volatile uint32_t*)0xE000ED08u)
#define SCB_AIRCR             (*(volatile uint32_t*)0xE000ED0Cu)
#define SCB_AIRCR_VECTKEY     (0x5FAu << 16)
#define SCB_AIRCR_SYSRESETREQ (1u << 2)

static inline void __disable_irq(void) { __asm volatile ("cpsid i" : : : "memory"); }
static inline void __enable_irq(void)  { __asm volatile ("cpsie i" : : : "memory"); }
static inline void __set_MSP(uint32_t topOfMainStack) { __asm volatile ("msr msp, %0" : : "r" (topOfMainStack) : "sp"); }
static inline void __DSB(void) { __asm volatile ("dsb 0xF":::"memory"); }
static inline void __ISB(void) { __asm volatile ("isb 0xF":::"memory"); }

/* ===================== Platform hooks (implement per target) ===================== */

__attribute__((weak)) void platform_init(void) { }
__attribute__((weak)) void platform_deinit(void) { }

__attribute__((weak)) int gpio_boot_pin_read(void) { return !BOOT_PIN_ACTIVE_LEVEL; } /* return 1 if asserted */
__attribute__((weak)) void led_set(int on) { (void)on; }

__attribute__((weak)) void uart_init(uint32_t baud) { (void)baud; }
__attribute__((weak)) void uart_deinit(void) { }
__attribute__((weak)) int uart_getc_timeout(uint32_t timeout_ms) { (void)timeout_ms; return -1; } /* -1 timeout, else 0..255 */
__attribute__((weak)) void uart_putc(uint8_t c) { (void)c; }
__attribute__((weak)) void uart_write(const void* buf, size_t len) { const uint8_t* p=(const uint8_t*)buf; while(len--) uart_putc(*p++); }

__attribute__((weak)) void delay_ms(uint32_t ms) { (void)ms; }

__attribute__((weak)) int flash_unlock(void) { return 0; }
__attribute__((weak)) int flash_lock(void) { return 0; }
__attribute__((weak)) int flash_erase_range(uint32_t addr, uint32_t len) { (void)addr; (void)len; return -1; }
__attribute__((weak)) int flash_program(uint32_t addr, const void* data, uint32_t len) { (void)addr; (void)data; (void)len; return -1; }
__attribute__((weak)) int flash_read(uint32_t addr, void* data, uint32_t len) { memcpy(data, (const void*)addr, len); return 0; }

/* Optional SD/FATFS hooks */
__attribute__((weak)) int sd_init(void) { return -1; }
__attribute__((weak)) void sd_deinit(void) { }
__attribute__((weak)) int sd_open(const char* path) { (void)path; return -1; }
__attribute__((weak)) int sd_read(void* buf, uint32_t len, uint32_t* out_read) { (void)buf; (void)len; if(out_read) *out_read=0; return -1; }
__attribute__((weak)) int sd_seek(uint32_t offset) { (void)offset; return -1; }
__attribute__((weak)) int sd_size(uint32_t* out_size) { (void)out_size; return -1; }
__attribute__((weak)) void sd_close(void) { }

/* ===================== CRC32 ===================== */

static uint32_t crc32_update(uint32_t crc, const void* data, size_t len)
{
    const uint8_t* p = (const uint8_t*)data;
    crc = ~crc;
    while (len--) {
        crc ^= *p++;
        for (unsigned k = 0; k < 8; k++) {
            uint32_t mask = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & mask);
        }
    }
    return ~crc;
}

/* ===================== Firmware header ===================== */

typedef struct {
    uint32_t magic;
    uint32_t size;
    uint32_t crc32;
    uint32_t reserved;
} fw_header_t;

/* ===================== App validity & jump ===================== */

static int is_valid_app(uint32_t app_base)
{
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rh = *(volatile uint32_t*)(app_base + 4);

    if (sp < 0x20000000u || sp > 0x20080000u) return 0; /* generic SRAM window */
    if (rh < APP_FLASH_BASE || rh >= APP_FLASH_LIMIT) return 0;
    if ((rh & 1u) == 0u) return 0; /* thumb */
    return 1;
}

typedef void (*app_entry_t)(void);

static void jump_to_app(uint32_t app_base)
{
    __disable_irq();

    uint32_t app_sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t app_pc = *(volatile uint32_t*)(app_base + 4);

    platform_deinit();
    uart_deinit();

    SCB_VTOR = app_base;
    __DSB();
    __ISB();

    __set_MSP(app_sp);
    __DSB();
    __ISB();

    ((app_entry_t)app_pc)();
    while (1) { }
}

/* ===================== Recovery magic ===================== */

static int recovery_magic_requested(void)
{
    volatile uint32_t* p = (volatile uint32_t*)BOOT_MAGIC_ADDR;
    return (*p == BOOT_MAGIC_VALUE);
}

static void clear_recovery_magic(void)
{
    volatile uint32_t* p = (volatile uint32_t*)BOOT_MAGIC_ADDR;
    *p = 0;
}

/* ===================== Flash writer ===================== */

typedef struct {
    uint32_t base;
    uint32_t limit;
    uint32_t write_addr;
    uint32_t total_written;
    uint32_t expected_size;
    uint32_t expected_crc;
    uint32_t running_crc;
    int      have_header;
} fw_writer_t;

static int fw_writer_begin(fw_writer_t* w, uint32_t base, uint32_t limit)
{
    memset(w, 0, sizeof(*w));
    w->base = base;
    w->limit = limit;
    w->write_addr = base;
    w->running_crc = 0;
    w->expected_size = 0;
    w->expected_crc = 0;
    w->have_header = 0;

    if (flash_unlock() != 0) return -1;
    return 0;
}

static int fw_writer_erase_for_size(uint32_t base, uint32_t size)
{
    if (size == 0 || size > MAX_FW_SIZE) return -1;
    uint32_t end = base + size;
    if (end > APP_FLASH_LIMIT) return -1;
    return flash_erase_range(base, size);
}

static int fw_writer_write(fw_writer_t* w, const uint8_t* data, uint32_t len)
{
    if (len == 0) return 0;
    if (w->write_addr + len > w->limit) return -1;

    if (flash_program(w->write_addr, data, len) != 0) return -1;

    w->running_crc = crc32_update(w->running_crc, data, len);
    w->write_addr += len;
    w->total_written += len;
    return 0;
}

static int fw_writer_end(fw_writer_t* w)
{
    (void)w;
    flash_lock();
    return 0;
}

/* ===================== UART XMODEM (CRC) receiver ===================== */

#define X_SOH 0x01
#define X_EOT 0x04
#define X_ACK 0x06
#define X_NAK 0x15
#define X_CAN 0x18
#define X_C   0x43

static uint16_t crc16_xmodem(const uint8_t* data, size_t len)
{
    uint16_t crc = 0;
    while (len--) {
        crc ^= (uint16_t)(*data++) << 8;
        for (unsigned i = 0; i < 8; i++) {
            if (crc & 0x8000) crc = (crc << 1) ^ 0x1021;
            else crc <<= 1;
        }
    }
    return crc;
}

static int uart_recv_byte(uint32_t timeout_ms)
{
    return uart_getc_timeout(timeout_ms);
}

static void uart_send_byte(uint8_t b)
{
    uart_putc(b);
}

static int xmodem_receive_to_flash(uint32_t timeout_ms, int allow_header)
{
    fw_writer_t w;
    if (fw_writer_begin(&w, APP_FLASH_BASE, APP_FLASH_LIMIT) != 0) return -1;

    uint8_t pkt[133]; /* SOH, blk, ~blk, 128 data, 2 crc */
    uint8_t data128[128];
    uint32_t total = 0;
    uint32_t expected_size = 0;
    uint32_t expected_crc = 0;
    int have_header = 0;
    int erased = 0;

    uart_send_byte(X_C);

    uint8_t blkno_expected = 1;

    while (1) {
        int c = uart_recv_byte(timeout_ms);
        if (c < 0) {
            uart_send_byte(X_C);
            continue;
        }

        if (c == X_EOT) {
            uart_send_byte(X_ACK);
            break;
        }
        if (c == X_CAN) {
            fw_writer_end(&w);
            return -2;
        }
        if (c != X_SOH) {
            continue;
        }

        pkt[0] = (uint8_t)c;
        for (int i = 1; i < 133; i++) {
            int b = uart_recv_byte(1000);
            if (b < 0) {
                uart_send_byte(X_NAK);
                goto next_packet;
            }
            pkt[i] = (uint8_t)b;
        }

        uint8_t blk = pkt[1];
        uint8_t blk_inv = pkt[2];
        if ((uint8_t)(blk ^ blk_inv) != 0xFFu) {
            uart_send_byte(X_NAK);
            goto next_packet;
        }

        memcpy(data128, &pkt[3], 128);
        uint16_t rx_crc = ((uint16_t)pkt[131] << 8) | pkt[132];
        uint16_t calc_crc = crc16_xmodem(data128, 128);
        if (rx_crc != calc_crc) {
            uart_send_byte(X_NAK);
            goto next_packet;
        }

        if (blk == (uint8_t)(blkno_expected - 1)) {
            uart_send_byte(X_ACK);
            goto next_packet;
        }

        if (blk != blkno_expected) {
            uart_send_byte(X_NAK);
            goto next_packet;
        }

        if (!have_header && allow_header) {
            fw_header_t hdr;
            memcpy(&hdr, data128, sizeof(hdr));
            if (hdr.magic == FW_HEADER_MAGIC && hdr.size > 0 && hdr.size <= MAX_FW_SIZE) {
                have_header = 1;
                expected_size = hdr.size;
                expected_crc = hdr.crc32;
                if (!erased) {
                    if (fw_writer_erase_for_size(APP_FLASH_BASE, expected_size) != 0) { fw_writer_end(&w); return -3; }
                    erased = 1;
                }
                uart_send_byte(X_ACK);
                blkno_expected++;
                goto next_packet;
            }
        }

        if (!erased) {
            uint32_t erase_size = MAX_FW_SIZE;
            if (fw_writer_erase_for_size(APP_FLASH_BASE, erase_size) != 0) { fw_writer_end(&w); return -3; }
            erased = 1;
        }

        uint32_t to_write = 128;
        if (have_header && expected_size) {
            if (total >= expected_size) to_write = 0;
            else to_write = MIN(128u, expected_size - total);
        }

        if (to_write) {
            if (fw_writer_write(&w, data128, to_write) != 0) { fw_writer_end(&w); return -4; }
            total += to_write;
        }

        uart_send_byte(X_ACK);
        blkno_expected++;

    next_packet:
        ;
    }

    fw_writer_end(&w);

    if (have_header && expected_size) {
        if (total != expected_size) return -5;
        if (w.running_crc != expected_crc) return -6;
    }

    return 0;
}

/* ===================== SD update ===================== */

static int sd_update_to_flash(int allow_header)
{
    if (sd_init() != 0) return -1;
    if (sd_open(SD_UPDATE_FILENAME) != 0) { sd_deinit(); return -2; }

    uint32_t fsize = 0;
    if (sd_size(&fsize) != 0) { sd_close(); sd_deinit(); return -3; }
    if (fsize == 0 || fsize > (MAX_FW_SIZE + sizeof(fw_header_t))) { sd_close(); sd_deinit(); return -4; }

    fw_header_t hdr;
    uint32_t rd = 0;
    if (sd_read(&hdr, sizeof(hdr), &rd) != 0 || rd != sizeof(hdr)) { sd_close(); sd_deinit(); return -5; }

    uint32_t expected_size = 0;
    uint32_t expected_crc = 0;
    int have_header = 0;

    if (allow_header && hdr.magic == FW_HEADER_MAGIC && hdr.size > 0 && hdr.size <= MAX_FW_SIZE) {
        have_header = 1;
        expected_size = hdr.size;
        expected_crc = hdr.crc32;
    } else {
        have_header = 0;
        expected_size = fsize;
        expected_crc = 0;
        if (sd_seek(0) != 0) { sd_close(); sd_deinit(); return -6; }
    }

    if (expected_size == 0 || expected_size > MAX_FW_SIZE) { sd_close(); sd_deinit(); return -7; }

    if (flash_unlock() != 0) { sd_close(); sd_deinit(); return -8; }
    if (fw_writer_erase_for_size(APP_FLASH_BASE, expected_size) != 0) { flash_lock(); sd_close(); sd_deinit(); return -9; }

    uint8_t buf[1024];
    uint32_t total = 0;
    uint32_t crc = 0;

    while (total < expected_size) {
        uint32_t want = MIN((uint32_t)sizeof(buf), expected_size - total);
        uint32_t got = 0;
        if (sd_read(buf, want, &got) != 0 || got == 0) { flash_lock(); sd_close(); sd_deinit(); return -10; }

        if (flash_program(APP_FLASH_BASE + total, buf, got) != 0) { flash_lock(); sd_close(); sd_deinit(); return -11; }
        crc = crc32_update(crc, buf, got);
        total += got;
    }

    flash_lock();
    sd_close();
    sd_deinit();

    if (have_header) {
        if (crc != expected_crc) return -12;
    }

    return 0;
}

/* ===================== Boot decision ===================== */

static int boot_pin_requested(void)
{
    return gpio_boot_pin_read() ? 1 : 0;
}

static int should_enter_bootloader(void)
{
    if (boot_pin_requested()) return 1;
    if (recovery_magic_requested()) return 1;
    if (!is_valid_app(APP_FLASH_BASE)) return 1;
    return 0;
}

/* ===================== Minimal status output ===================== */

static void uart_print(const char* s)
{
    uart_write(s, strlen(s));
}

static void system_reset(void)
{
    __disable_irq();
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    __DSB();
    while (1) { }
}

/* ===================== Main bootloader ===================== */

static int try_sd_update(void)
{
    int r = sd_update_to_flash(1);
    return r;
}

static int try_uart_update(void)
{
    uart_init(UART_BAUDRATE);

    /* If host sends 'U' quickly, start XMODEM; else timeout and return */
    uint32_t waited = 0;
    while (waited < UART_UPDATE_TIMEOUT_MS) {
        int c = uart_getc_timeout(50);
        if (c >= 0) {
            if ((uint8_t)c == 'U') {
                uart_print("XMODEM\r\n");
                return xmodem_receive_to_flash(1000, 1);
            }
        }
        waited += 50;
    }
    return 1; /* no update */
}

int main(void)
{
    platform_init();

    if (!should_enter_bootloader()) {
        jump_to_app(APP_FLASH_BASE);
    }

    clear_recovery_magic();

    led_set(1);

    /* Fast update preference: SD first (if present), then UART */
    int sd_r = try_sd_update();
    if (sd_r == 0) {
        led_set(0);
        if (is_valid_app(APP_FLASH_BASE)) jump_to_app(APP_FLASH_BASE);
        system_reset();
    }

    int uart_r = try_uart_update();
    if (uart_r == 0) {
        led_set(0);
        if (is_valid_app(APP_FLASH_BASE)) jump_to_app(APP_FLASH_BASE);
        system_reset();
    }

    led_set(0);

    if (is_valid_app(APP_FLASH_BASE)) {
        jump_to_app(APP_FLASH_BASE);
    }

    /* Stay in bootloader waiting for UART update */
    uart_init(UART_BAUDRATE);
    uart_print("BOOT\r\nSend 'U' then XMODEM\r\n");
    while (1) {
        int r = xmodem_receive_to_flash(1000, 1);
        if (r == 0 && is_valid_app(APP_FLASH_BASE)) {
            uart_print("OK\r\n");
            delay_ms(50);
            jump_to_app(APP_FLASH_BASE);
        } else {
            uart_print("ERR\r\n");
        }
    }
}