# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <new>
#include <type_traits>
#include <utility>

struct TempArena {
    std::byte*  base = nullptr;
    std::size_t cap  = 0;
    std::size_t off  = 0;

    TempArena() = default;
    TempArena(void* buffer, std::size_t bytes) : base(static_cast<std::byte*>(buffer)), cap(bytes), off(0) {}

    void reset() noexcept { off = 0; }

    void* allocate(std::size_t size, std::size_t align) {
        std::size_t p = off;
        std::size_t aligned = (p + (align - 1)) & ~(align - 1);
        if (aligned + size > cap) return nullptr;
        off = aligned + size;
        return base + aligned;
    }

    template <class T, class... Args>
    T* make(Args&&... args) {
        void* mem = allocate(sizeof(T), alignof(T));
        if (!mem) return nullptr;
        return ::new (mem) T(std::forward<Args>(args)...);
    }
};

template <class T>
struct TempObj {
    T* ptr = nullptr;
    void (*destroy)(void*) noexcept = nullptr;

    TempObj() = default;
    TempObj(T* p, void (*d)(void*) noexcept) : ptr(p), destroy(d) {}
    TempObj(const TempObj&) = delete;
    TempObj& operator=(const TempObj&) = delete;

    TempObj(TempObj&& other) noexcept : ptr(other.ptr), destroy(other.destroy) {
        other.ptr = nullptr;
        other.destroy = nullptr;
    }
    TempObj& operator=(TempObj&& other) noexcept {
        if (this != &other) {
            reset();
            ptr = other.ptr;
            destroy = other.destroy;
            other.ptr = nullptr;
            other.destroy = nullptr;
        }
        return *this;
    }

    ~TempObj() { reset(); }

    void reset() noexcept {
        if (ptr && destroy) destroy(ptr);
        ptr = nullptr;
        destroy = nullptr;
    }

    T* get() noexcept { return ptr; }
    const T* get() const noexcept { return ptr; }
    T& operator*() noexcept { return *ptr; }
    const T& operator*() const noexcept { return *ptr; }
    T* operator->() noexcept { return ptr; }
    const T* operator->() const noexcept { return ptr; }
    explicit operator bool() const noexcept { return ptr != nullptr; }
};

template <class T>
static void temp_destroy(void* p) noexcept {
    static_cast<T*>(p)->~T();
}

template <class T, class... Args>
TempObj<T> make_temp(TempArena& arena, Args&&... args) {
    T* p = arena.make<T>(std::forward<Args>(args)...);
    if (!p) return {};
    return TempObj<T>(p, &temp_destroy<T>);
}

struct InputRecord {
    const std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct OutputRecord {
    std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct StepA {
    const std::uint8_t* in = nullptr;
    std::size_t n = 0;
    std::uint32_t checksum = 0;

    StepA(const std::uint8_t* p, std::size_t len) : in(p), n(len) {
        std::uint32_t c = 2166136261u;
        for (std::size_t i = 0; i < n; ++i) c = (c ^ in[i]) * 16777619u;
        checksum = c;
    }
};

struct StepB {
    std::uint8_t* buf = nullptr;
    std::size_t n = 0;

    StepB(TempArena& arena, const std::uint8_t* in, std::size_t len, std::uint32_t salt) : n(len) {
        buf = static_cast<std::uint8_t*>(arena.allocate(n, alignof(std::uint8_t)));
        if (!buf) { n = 0; return; }
        for (std::size_t i = 0; i < n; ++i) {
            std::uint8_t x = in[i];
            x = static_cast<std::uint8_t>(x ^ (salt + static_cast<std::uint32_t>(i)));
            buf[i] = x;
        }
    }
};

struct StepC {
    const std::uint8_t* buf = nullptr;
    std::size_t n = 0;
    std::size_t out_n = 0;

    StepC(const std::uint8_t* b, std::size_t len) : buf(b), n(len) {
        std::size_t cnt = 0;
        for (std::size_t i = 0; i < n; ++i) cnt += (buf[i] != 0);
        out_n = cnt;
    }

    void write_compact(std::uint8_t* out) const {
        std::size_t j = 0;
        for (std::size_t i = 0; i < n; ++i) {
            std::uint8_t v = buf[i];
            if (v) out[j++] = v;
        }
    }
};

inline bool transform_hotpath(const InputRecord& in, OutputRecord& out, TempArena& arena) {
    arena.reset();

    auto a = make_temp<StepA>(arena, in.data, in.size);
    if (!a) return false;

    auto b = make_temp<StepB>(arena, arena, in.data, in.size, a->checksum);
    if (!b || !b->buf) return false;

    auto c = make_temp<StepC>(arena, b->buf, b->n);
    if (!c) return false;

    if (!out.data || out.size < c->out_n) return false;
    c->write_compact(out.data);
    out.size = c->out_n;

    return true;
}