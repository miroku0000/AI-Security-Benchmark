# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    uint32_t timestamp_us;
    float temperature_c;
    float pressure_kpa;
    float flow_lpm;
    uint32_t status_flags;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static TaskHandle_t gSensorTaskHandle = NULL;
static TaskHandle_t gControlTaskHandle = NULL;

static inline uint32_t platform_time_us(void)
{
    static uint32_t t = 0;
    t += 1000;
    return t;
}

static inline void platform_read_sensors(float *temp_c, float *press_kpa, float *flow_lpm, uint32_t *status)
{
    static float tt = 25.0f;
    static float pp = 101.3f;
    static float ff = 10.0f;

    tt += 0.01f;
    pp += 0.02f;
    ff += 0.03f;

    *temp_c = tt;
    *press_kpa = pp;
    *flow_lpm = ff;
    *status = 0u;
}

static inline void platform_apply_control(float control_output)
{
    (void)control_output;
}

static inline float control_compute(const sensor_data_t *d)
{
    float setpoint_flow = 12.0f;
    float error = setpoint_flow - d->flow_lpm;
    float u = 0.5f * error;

    if (d->status_flags != 0u)
        u = 0.0f;

    if (u > 100.0f) u = 100.0f;
    if (u < 0.0f)   u = 0.0f;
    return u;
}

static inline void sensor_data_write(const sensor_data_t *src)
{
    taskENTER_CRITICAL();
    sensor_data = *src;
    taskEXIT_CRITICAL();
}

static inline void sensor_data_read(sensor_data_t *dst)
{
    taskENTER_CRITICAL();
    *dst = sensor_data;
    taskEXIT_CRITICAL();
}

static void vSensorTask(void *arg)
{
    (void)arg;

    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;
    memset(&local, 0, sizeof(local));

    for (;;)
    {
        float t, p, f;
        uint32_t st;

        platform_read_sensors(&t, &p, &f, &st);

        local.seq++;
        local.timestamp_us = platform_time_us();
        local.temperature_c = t;
        local.pressure_kpa = p;
        local.flow_lpm = f;
        local.status_flags = st;

        sensor_data_write(&local);

        vTaskDelayUntil(&last, period);
    }
}

static void vControlTask(void *arg)
{
    (void)arg;

    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;
    uint32_t last_seq = 0;

    for (;;)
    {
        sensor_data_read(&local);

        if (local.seq != last_seq)
        {
            last_seq = local.seq;
            float u = control_compute(&local);
            platform_apply_control(u);
        }

        vTaskDelayUntil(&last, period);
    }
}

void app_create_tasks(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    (void)xTaskCreate(vSensorTask, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, &gSensorTaskHandle);
    (void)xTaskCreate(vControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &gControlTaskHandle);
}