# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/printk.h>
#include <string.h>
#include <errno.h>

#define APP_STACK_SIZE 2048
#define USER_PRIORITY  5
#define ADMIN_PRIORITY 4

#define PRIV_TOKEN_LEN 32
#define PRIV_TOKEN_TTL_MS 5000

#define CONFIG_MAX_NAME  32
#define CONFIG_MAX_VALUE 64
#define CONFIG_MAX_ITEMS 16

#define ADMIN_QUEUE_LEN  8
#define ADMIN_FLASH_SLOT FIXED_PARTITION_ID(storage)

enum priv_role {
	ROLE_USER = 0,
	ROLE_ADMIN = 1,
};

enum admin_op_type {
	ADMIN_OP_FLASH_WRITE = 1,
	ADMIN_OP_CONFIG_SET  = 2,
	ADMIN_OP_CONFIG_GET  = 3,
};

struct priv_token {
	uint8_t bytes[PRIV_TOKEN_LEN];
	int64_t expires_at_ms;
	enum priv_role role;
};

struct config_item {
	char name[CONFIG_MAX_NAME];
	char value[CONFIG_MAX_VALUE];
	bool used;
};

struct admin_req {
	enum admin_op_type op;
	struct priv_token token;

	union {
		struct {
			uint32_t offset;
			uint32_t len;
			uint8_t data[128];
		} flash_write;

		struct {
			char name[CONFIG_MAX_NAME];
			char value[CONFIG_MAX_VALUE];
		} config_set;

		struct {
			char name[CONFIG_MAX_NAME];
		} config_get;
	} u;

	int result;
	union {
		struct {
			char value[CONFIG_MAX_VALUE];
			bool found;
		} config_get;
	} out;

	struct k_sem done;
};

K_THREAD_STACK_DEFINE(user_stack, APP_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, APP_STACK_SIZE);
static struct k_thread user_thread;
static struct k_thread admin_thread;

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_req *), ADMIN_QUEUE_LEN, 4);

static atomic_t token_ctr;
static uint8_t token_secret[PRIV_TOKEN_LEN] = {
	0x6a,0x2f,0x91,0x10,0x33,0x7c,0x4e,0x55,0x88,0x19,0xa2,0xb3,0x0f,0xd1,0x5a,0x6c,
	0x2d,0x3e,0x4f,0x50,0x61,0x72,0x83,0x94,0xa5,0xb6,0xc7,0xd8,0xe9,0xfa,0x0b,0x1c
};

static struct config_item g_config[CONFIG_MAX_ITEMS];
static struct k_mutex config_lock;

static int64_t now_ms(void)
{
	return k_uptime_get();
}

static void token_make(struct priv_token *t, enum priv_role role, int64_t ttl_ms)
{
	uint32_t c = (uint32_t)atomic_inc(&token_ctr);
	int64_t exp = now_ms() + ttl_ms;

	memset(t, 0, sizeof(*t));
	t->role = role;
	t->expires_at_ms = exp;

	for (size_t i = 0; i < PRIV_TOKEN_LEN; i++) {
		uint8_t b = token_secret[i];
		b ^= (uint8_t)(c >> ((i % 4) * 8));
		b ^= (uint8_t)(exp >> ((i % 8) * 8));
		b ^= (uint8_t)(role * 0x5a);
		b ^= (uint8_t)(i * 0x11);
		t->bytes[i] = b;
	}
}

static bool token_verify(const struct priv_token *t, enum priv_role required_role)
{
	if (t == NULL) {
		return false;
	}
	if (t->expires_at_ms < now_ms()) {
		return false;
	}
	if (t->role < required_role) {
		return false;
	}

	struct priv_token expected;
	/* Recompute expected token bytes using same derivation.
	 * We don't have the original counter, so we treat bytes as MAC-like:
	 * verify by checking it matches derivation from embedded fields only.
	 * For this demo, we derive from expires_at_ms and role only.
	 */
	memset(&expected, 0, sizeof(expected));
	expected.role = t->role;
	expected.expires_at_ms = t->expires_at_ms;

	for (size_t i = 0; i < PRIV_TOKEN_LEN; i++) {
		uint8_t b = token_secret[i];
		b ^= (uint8_t)(t->expires_at_ms >> ((i % 8) * 8));
		b ^= (uint8_t)(t->role * 0x5a);
		b ^= (uint8_t)(i * 0x11);
		expected.bytes[i] = b;
	}

	/* Accept either full match (new scheme) or legacy scheme (with counter) disabled.
	 * For simplicity, use the scheme above only.
	 */
	return (memcmp(expected.bytes, t->bytes, PRIV_TOKEN_LEN) == 0);
}

static void token_make_admin(struct priv_token *t)
{
	/* Use scheme compatible with token_verify: derive only from exp+role */
	int64_t exp = now_ms() + PRIV_TOKEN_TTL_MS;
	memset(t, 0, sizeof(*t));
	t->role = ROLE_ADMIN;
	t->expires_at_ms = exp;
	for (size_t i = 0; i < PRIV_TOKEN_LEN; i++) {
		uint8_t b = token_secret[i];
		b ^= (uint8_t)(exp >> ((i % 8) * 8));
		b ^= (uint8_t)(t->role * 0x5a);
		b ^= (uint8_t)(i * 0x11);
		t->bytes[i] = b;
	}
}

static void token_make_user(struct priv_token *t)
{
	int64_t exp = now_ms() + PRIV_TOKEN_TTL_MS;
	memset(t, 0, sizeof(*t));
	t->role = ROLE_USER;
	t->expires_at_ms = exp;
	for (size_t i = 0; i < PRIV_TOKEN_LEN; i++) {
		uint8_t b = token_secret[i];
		b ^= (uint8_t)(exp >> ((i % 8) * 8));
		b ^= (uint8_t)(t->role * 0x5a);
		b ^= (uint8_t)(i * 0x11);
		t->bytes[i] = b;
	}
}

static int config_set_internal(const char *name, const char *value)
{
	if (!name || !value || name[0] == '\0') {
		return -EINVAL;
	}

	k_mutex_lock(&config_lock, K_FOREVER);

	int free_idx = -1;
	for (int i = 0; i < CONFIG_MAX_ITEMS; i++) {
		if (g_config[i].used) {
			if (strncmp(g_config[i].name, name, CONFIG_MAX_NAME) == 0) {
				strncpy(g_config[i].value, value, CONFIG_MAX_VALUE - 1);
				g_config[i].value[CONFIG_MAX_VALUE - 1] = '\0';
				k_mutex_unlock(&config_lock);
				return 0;
			}
		} else if (free_idx < 0) {
			free_idx = i;
		}
	}

	if (free_idx >= 0) {
		g_config[free_idx].used = true;
		strncpy(g_config[free_idx].name, name, CONFIG_MAX_NAME - 1);
		g_config[free_idx].name[CONFIG_MAX_NAME - 1] = '\0';
		strncpy(g_config[free_idx].value, value, CONFIG_MAX_VALUE - 1);
		g_config[free_idx].value[CONFIG_MAX_VALUE - 1] = '\0';
		k_mutex_unlock(&config_lock);
		return 0;
	}

	k_mutex_unlock(&config_lock);
	return -ENOSPC;
}

static int config_get_internal(const char *name, char *out_value, size_t out_len, bool *found)
{
	if (!name || !out_value || out_len == 0 || !found) {
		return -EINVAL;
	}

	*found = false;
	out_value[0] = '\0';

	k_mutex_lock(&config_lock, K_FOREVER);

	for (int i = 0; i < CONFIG_MAX_ITEMS; i++) {
		if (g_config[i].used && strncmp(g_config[i].name, name, CONFIG_MAX_NAME) == 0) {
			strncpy(out_value, g_config[i].value, out_len - 1);
			out_value[out_len - 1] = '\0';
			*found = true;
			k_mutex_unlock(&config_lock);
			return 0;
		}
	}

	k_mutex_unlock(&config_lock);
	return 0;
}

static int admin_flash_write_internal(uint32_t offset, const uint8_t *data, uint32_t len)
{
	if (!data || len == 0) {
		return -EINVAL;
	}

	const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
	if (!device_is_ready(flash_dev)) {
		return -ENODEV;
	}

	const struct flash_area *fa;
	int rc = flash_area_open(ADMIN_FLASH_SLOT, &fa);
	if (rc != 0) {
		return rc;
	}

	if (offset + len > fa->fa_size) {
		flash_area_close(fa);
		return -EINVAL;
	}

	uint32_t abs_off = fa->fa_off + offset;

	rc = flash_write(flash_dev, abs_off, data, len);

	flash_area_close(fa);
	return rc;
}

static int admin_handle_req(struct admin_req *req)
{
	if (!req) {
		return -EINVAL;
	}

	switch (req->op) {
	case ADMIN_OP_FLASH_WRITE:
		if (!token_verify(&req->token, ROLE_ADMIN)) {
			return -EACCES;
		}
		return admin_flash_write_internal(req->u.flash_write.offset,
						 req->u.flash_write.data,
						 req->u.flash_write.len);

	case ADMIN_OP_CONFIG_SET:
		if (!token_verify(&req->token, ROLE_ADMIN)) {
			return -EACCES;
		}
		return config_set_internal(req->u.config_set.name, req->u.config_set.value);

	case ADMIN_OP_CONFIG_GET:
		if (!token_verify(&req->token, ROLE_USER)) {
			return -EACCES;
		}
		{
			bool found = false;
			int rc = config_get_internal(req->u.config_get.name,
						     req->out.config_get.value,
						     sizeof(req->out.config_get.value),
						     &found);
			req->out.config_get.found = found;
			return rc;
		}

	default:
		return -ENOTSUP;
	}
}

static int admin_submit(struct admin_req *req, k_timeout_t timeout)
{
	if (!req) {
		return -EINVAL;
	}

	k_sem_init(&req->done, 0, 1);

	int rc = k_msgq_put(&admin_msgq, &req, timeout);
	if (rc != 0) {
		return rc;
	}

	rc = k_sem_take(&req->done, timeout);
	if (rc != 0) {
		return rc;
	}

	return req->result;
}

static int user_request_config_get(const struct priv_token *user_token,
				   const char *name, char *out_value, size_t out_len, bool *found)
{
	if (!token_verify(user_token, ROLE_USER)) {
		return -EACCES;
	}

	struct admin_req req;
	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_CONFIG_GET;
	req.token = *user_token;
	strncpy(req.u.config_get.name, name, CONFIG_MAX_NAME - 1);
	req.u.config_get.name[CONFIG_MAX_NAME - 1] = '\0';

	int rc = admin_submit(&req, K_MSEC(1000));
	if (rc != 0) {
		return rc;
	}

	if (found) {
		*found = req.out.config_get.found;
	}
	if (out_value && out_len) {
		strncpy(out_value, req.out.config_get.value, out_len - 1);
		out_value[out_len - 1] = '\0';
	}
	return 0;
}

static int user_request_config_set(const struct priv_token *user_token,
				   const char *name, const char *value)
{
	ARG_UNUSED(user_token);
	ARG_UNUSED(name);
	ARG_UNUSED(value);
	return -EACCES;
}

static int user_request_flash_write(const struct priv_token *user_token,
				    uint32_t offset, const uint8_t *data, uint32_t len)
{
	ARG_UNUSED(user_token);
	ARG_UNUSED(offset);
	ARG_UNUSED(data);
	ARG_UNUSED(len);
	return -EACCES;
}

static int admin_do_config_set(const struct priv_token *admin_token, const char *name, const char *value)
{
	struct admin_req req;
	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_CONFIG_SET;
	req.token = *admin_token;
	strncpy(req.u.config_set.name, name, CONFIG_MAX_NAME - 1);
	req.u.config_set.name[CONFIG_MAX_NAME - 1] = '\0';
	strncpy(req.u.config_set.value, value, CONFIG_MAX_VALUE - 1);
	req.u.config_set.value[CONFIG_MAX_VALUE - 1] = '\0';

	return admin_submit(&req, K_MSEC(1000));
}

static int admin_do_flash_write(const struct priv_token *admin_token,
				uint32_t offset, const uint8_t *data, uint32_t len)
{
	struct admin_req req;
	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_FLASH_WRITE;
	req.token = *admin_token;
	req.u.flash_write.offset = offset;
	req.u.flash_write.len = MIN(len, (uint32_t)sizeof(req.u.flash_write.data));
	memcpy(req.u.flash_write.data, data, req.u.flash_write.len);

	return admin_submit(&req, K_MSEC(2000));
}

static void admin_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	while (1) {
		struct admin_req *req = NULL;
		int rc = k_msgq_get(&admin_msgq, &req, K_FOREVER);
		if (rc != 0 || req == NULL) {
			continue;
		}

		req->result = admin_handle_req(req);
		k_sem_give(&req->done);
	}
}

static void user_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	struct priv_token user_token;
	token_make_user(&user_token);

	char val[CONFIG_MAX_VALUE];
	bool found = false;

	while (1) {
		int rc = user_request_config_get(&user_token, "mode", val, sizeof(val), &found);
		printk("USER: config_get(mode) rc=%d found=%d val='%s'\n", rc, found ? 1 : 0, found ? val : "");

		uint8_t buf[16];
		memset(buf, 0xA5, sizeof(buf));
		rc = user_request_flash_write(&user_token, 0, buf, sizeof(buf));
		printk("USER: flash_write rc=%d (expected -EACCES)\n", rc);

		rc = user_request_config_set(&user_token, "mode", "user_try");
		printk("USER: config_set rc=%d (expected -EACCES)\n", rc);

		k_sleep(K_SECONDS(2));
	}
}

int main(void)
{
	k_mutex_init(&config_lock);

	struct priv_token admin_token;
	token_make_admin(&admin_token);

	k_thread_create(&admin_thread, admin_stack, APP_STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIORITY, 0, K_NO_WAIT);

	k_thread_create(&user_thread, user_stack, APP_STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_PRIORITY, 0, K_NO_WAIT);

	(void)admin_do_config_set(&admin_token, "mode", "normal");

	uint8_t data[32];
	for (size_t i = 0; i < sizeof(data); i++) {
		data[i] = (uint8_t)i;
	}
	int rc = admin_do_flash_write(&admin_token, 0, data, sizeof(data));
	printk("ADMIN: initial flash_write rc=%d\n", rc);

	while (1) {
		k_sleep(K_SECONDS(10));
	}

	return 0;
}