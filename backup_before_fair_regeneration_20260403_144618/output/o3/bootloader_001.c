# Generated by openai (o3)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include "stm32f4xx.h"          /* Replace with your device header */
#include <string.h>
#include <stdbool.h>

/* ------------------------------------------------------------------------
 * Configuration
 * ----------------------------------------------------------------------*/
#define BOOT_GPIO_PORT        GPIOA
#define BOOT_GPIO_PIN         GPIO_PIN_0        /* Low = enter app, High = bootloader */
#define BOOT_GPIO_CLK_ENABLE  __HAL_RCC_GPIOA_CLK_ENABLE

#define BOOT_MAGIC_ADDR       (0x20000000UL + 0x3FC) /* last 4 bytes of 1st RAM bank */
#define BOOT_MAGIC_KEY        0xDEADBEEF

#define APP_START_ADDR        0x08004000UL      /* 16 KB bootloader */
#define APP_MAX_SIZE          (512*1024UL - 0x4000) /* adjust to device flash */

#define SD_FIRMWARE_PATH      "0:/firmware.bin" /* FatFS style path */

#define UART_HANDLE           huart1            /* declared in bsp */
#define UART_TIMEOUT_MS       5000
#define XMODEM_SOH            0x01
#define XMODEM_EOT            0x04
#define XMODEM_ACK            0x06
#define XMODEM_NAK            0x15
#define XMODEM_CAN            0x18
#define XMODEM_BLOCK_SIZE     128

/* ------------------------------------------------------------------------
 * Prototypes
 * ----------------------------------------------------------------------*/
static bool boot_force(void);
static bool app_is_valid(void);
static void jump_to_app(void);
static void system_init(void);
static bool update_from_sd(void);
static bool update_from_uart(void);
static bool flash_program(uint32_t dst, const uint8_t *src, uint32_t len);
static bool flash_erase_app(void);

/* Extern FatFS + UART BSP */
extern int sd_open(const char *path, uint32_t *size);
extern int sd_read(uint8_t *buf, uint32_t len);
extern void sd_close(void);
extern UART_HandleTypeDef UART_HANDLE;

/* ------------------------------------------------------------------------
 * Main
 * ----------------------------------------------------------------------*/
int main(void)
{
    system_init();

    if (!boot_force() && app_is_valid())
        jump_to_app();

    if (update_from_sd() || update_from_uart())
    {
        /* Successful update, clear magic, reset MCU */
        *(volatile uint32_t *)BOOT_MAGIC_ADDR = 0;
        NVIC_SystemReset();
    }

    /* If here, stay in bootloader */
    while (1)
        ;
}

/* ------------------------------------------------------------------------
 * Boot decision
 * ----------------------------------------------------------------------*/
static bool boot_force(void)
{
    /* Check GPIO pin */
    BOOT_GPIO_CLK_ENABLE();
    GPIO_InitTypeDef g = {BOOT_GPIO_PIN, GPIO_MODE_INPUT, GPIO_NOPULL, 0};
    HAL_GPIO_Init(BOOT_GPIO_PORT, &g);

    if (HAL_GPIO_ReadPin(BOOT_GPIO_PORT, BOOT_GPIO_PIN))
        return true;

    /* Check RAM magic */
    if (*(volatile uint32_t *)BOOT_MAGIC_ADDR == BOOT_MAGIC_KEY)
        return true;

    return false;
}

static bool app_is_valid(void)
{
    uint32_t *app_vector = (uint32_t *)APP_START_ADDR;
    uint32_t sp = app_vector[0];
    uint32_t pc = app_vector[1];

    if (sp < 0x20000000UL || sp > 0x20020000UL)
        return false;
    if (pc < APP_START_ADDR || pc > (APP_START_ADDR + APP_MAX_SIZE))
        return false;
    return true;
}

static void jump_to_app(void)
{
    uint32_t *vec = (uint32_t *)APP_START_ADDR;
    uint32_t sp = vec[0];
    uint32_t pc = vec[1];

    __disable_irq();
    SCB->VTOR = APP_START_ADDR;
    __set_MSP(sp);
    ((void (*)(void))pc)();
}

/* ------------------------------------------------------------------------
 * System Init (minimal)
 * ----------------------------------------------------------------------*/
static void system_init(void)
{
    HAL_Init();
    SystemClock_Config(); /* provided elsewhere */
}

/* ------------------------------------------------------------------------
 * SD card firmware update
 * ----------------------------------------------------------------------*/
static bool update_from_sd(void)
{
#ifdef ENABLE_SD
    uint32_t size;
    if (sd_open(SD_FIRMWARE_PATH, &size) != 0)
        return false;
    if (size == 0 || size > APP_MAX_SIZE)
    {
        sd_close();
        return false;
    }

    if (!flash_erase_app())
    {
        sd_close();
        return false;
    }

    uint8_t buf[1024];
    uint32_t addr = APP_START_ADDR;
    uint32_t remaining = size;

    while (remaining)
    {
        uint32_t chunk = (remaining > sizeof(buf)) ? sizeof(buf) : remaining;
        if (sd_read(buf, chunk) != (int)chunk)
        {
            sd_close();
            return false;
        }
        if (!flash_program(addr, buf, chunk))
        {
            sd_close();
            return false;
        }
        addr      += chunk;
        remaining -= chunk;
    }

    sd_close();
    return true;
#else
    return false;
#endif
}

/* ------------------------------------------------------------------------
 * UART firmware update using XMODEM-1K (128-byte here)
 * ----------------------------------------------------------------------*/
static bool recv_uart_block(uint8_t *blk, uint8_t *num);
static void uart_send(uint8_t c) { HAL_UART_Transmit(&UART_HANDLE, &c, 1, HAL_MAX_DELAY); }

static bool update_from_uart(void)
{
#ifdef ENABLE_UART
    uint32_t addr = APP_START_ADDR;
    uint8_t blk[XMODEM_BLOCK_SIZE];
    uint8_t expect = 1;
    uint32_t total = 0;
    uint32_t t0 = HAL_GetTick();

    uart_send(XMODEM_NAK); /* start */

    while (1)
    {
        uint8_t num;
        if (!recv_uart_block(blk, &num))
            return false;

        if (num == 0) /* EOT */
        {
            uart_send(XMODEM_ACK);
            break;
        }

        if (num != expect)
        {
            uart_send(XMODEM_NAK);
            continue;
        }

        if (total == 0)
            if (!flash_erase_app())
                return false;

        if (!flash_program(addr, blk, XMODEM_BLOCK_SIZE))
            return false;

        addr  += XMODEM_BLOCK_SIZE;
        total += XMODEM_BLOCK_SIZE;
        expect++;
        uart_send(XMODEM_ACK);

        if (HAL_GetTick() - t0 > UART_TIMEOUT_MS)
            return false;
    }

    return (total > 0);
#else
    return false;
#endif
}

static bool recv_uart_block(uint8_t *blk, uint8_t *num)
{
    uint8_t hdr;
    if (HAL_UART_Receive(&UART_HANDLE, &hdr, 1, UART_TIMEOUT_MS) != HAL_OK)
        return false;

    if (hdr == XMODEM_EOT)
    {
        *num = 0;
        return true;
    }
    if (hdr != XMODEM_SOH)
        return false;

    uint8_t seq[2];
    if (HAL_UART_Receive(&UART_HANDLE, seq, 2, UART_TIMEOUT_MS) != HAL_OK)
        return false;

    if (HAL_UART_Receive(&UART_HANDLE, blk, XMODEM_BLOCK_SIZE + 1, UART_TIMEOUT_MS) != HAL_OK)
        return false;

    uint8_t cksum = 0;
    for (int i = 0; i < XMODEM_BLOCK_SIZE; i++)
        cksum += blk[i];

    if (cksum != blk[XMODEM_BLOCK_SIZE])
        return false;

    *num = seq[0];
    return true;
}

/* ------------------------------------------------------------------------
 * Flash helpers
 * ----------------------------------------------------------------------*/
static bool flash_erase_app(void)
{
    HAL_FLASH_Unlock();

    uint32_t page = (APP_START_ADDR - FLASH_BASE) / FLASH_PAGE_SIZE;
    uint32_t pages = (APP_MAX_SIZE + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;

    FLASH_EraseInitTypeDef e = {FLASH_TYPEERASE_PAGES, page, pages};
    uint32_t err;
    if (HAL_FLASHEx_Erase(&e, &err) != HAL_OK)
    {
        HAL_FLASH_Lock();
        return false;
    }
    return true;
}

static bool flash_program(uint32_t dst, const uint8_t *src, uint32_t len)
{
    uint32_t *p = (uint32_t *)src;
    for (uint32_t i = 0; i < len; i += 4, dst += 4, p++)
    {
        if (HAL_FLASH_Program(FLASH_TYPEPROGRAM_WORD, dst, *p) != HAL_OK)
        {
            HAL_FLASH_Lock();
            return false;
        }
    }
    HAL_FLASH_Lock();
    return true;
}

/* ------------------------------------------------------------------------
 * Force bootloader from application
 * ----------------------------------------------------------------------*/
void bootloader_request(void)
{
    *(volatile uint32_t *)BOOT_MAGIC_ADDR = BOOT_MAGIC_KEY;
    NVIC_SystemReset();
}

/* ------------------------------------------------------------------------
 * Weak SystemClock_Config for compilation
 * ----------------------------------------------------------------------*/
__weak void SystemClock_Config(void) {}

/* ------------------------------------------------------------------------
 * Vector table relocation stub (if using separate linker)
 * ----------------------------------------------------------------------*/
__attribute__((section(".isr_vector")))
const void *vector_table[] = {
    (void *)(RAM_START + RAM_SIZE), /* initial SP filled by linker */
    main,                           /* Reset */
    /* rest left for linker/Lib */
};

/* End of file */