# Generated by openai (o3)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <stdexcept>
#include <cstring>
#include <cerrno>
#include <unistd.h>
#include <arpa/inet.h>
#include <sys/socket.h>
#include <netinet/in.h>

class ConnectionManager {
public:
    ConnectionManager(const std::string& host, uint16_t port)
        : host_(host), port_(port), sockfd_(-1) {
        openConnection();
    }

    ~ConnectionManager() noexcept {
        cleanup();
    }

    ConnectionManager(const ConnectionManager&) = delete;
    ConnectionManager& operator=(const ConnectionManager&) = delete;

    ConnectionManager(ConnectionManager&& other) noexcept
        : host_(std::move(other.host_)), port_(other.port_), sockfd_(other.sockfd_) {
        other.sockfd_ = -1;
    }

    ConnectionManager& operator=(ConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            host_   = std::move(other.host_);
            port_   = other.port_;
            sockfd_ = other.sockfd_;
            other.sockfd_ = -1;
        }
        return *this;
    }

    void reset() {
        cleanup();
        openConnection();
    }

    void reinit(const std::string& newHost, uint16_t newPort) {
        cleanup();
        host_ = newHost;
        port_ = newPort;
        openConnection();
    }

    int socket() const noexcept { return sockfd_; }

private:
    std::string host_;
    uint16_t    port_;
    int         sockfd_;

    void openConnection() {
        sockfd_ = ::socket(AF_INET, SOCK_STREAM, 0);
        if (sockfd_ == -1) {
            throw std::runtime_error(std::string("socket() failed: ") + std::strerror(errno));
        }

        sockaddr_in addr {};
        addr.sin_family = AF_INET;
        addr.sin_port   = htons(port_);

        if (::inet_pton(AF_INET, host_.c_str(), &addr.sin_addr) <= 0) {
            int savedErr = errno;
            cleanup();
            throw std::runtime_error(std::string("inet_pton() failed: ") + std::strerror(savedErr));
        }

        if (::connect(sockfd_, reinterpret_cast<sockaddr*>(&addr), sizeof(addr)) == -1) {
            int savedErr = errno;
            cleanup();
            throw std::runtime_error(std::string("connect() failed: ") + std::strerror(savedErr));
        }
    }

    void cleanup() noexcept {
        if (sockfd_ != -1) {
            ::close(sockfd_);
            sockfd_ = -1;
        }
    }
};