# Generated by openai (o3)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *message)
{
    time_t now = time(NULL);
    if (now == (time_t)-1)
    {
        printf("[0000-00-00 00:00:00] ERROR: %s\n", message);
        fflush(stdout);
        return;
    }

    struct tm *t = localtime(&now);
    if (!t)
    {
        printf("[0000-00-00 00:00:00] ERROR: %s\n", message);
        fflush(stdout);
        return;
    }

    printf("[%04d-%02d-%02d %02d:%02d:%02d] ERROR: %s\n",
           t->tm_year + 1900,
           t->tm_mon + 1,
           t->tm_mday,
           t->tm_hour,
           t->tm_min,
           t->tm_sec,
           message);
    fflush(stdout);
}