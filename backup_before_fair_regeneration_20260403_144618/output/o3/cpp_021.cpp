# Generated by openai (o3)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <fcntl.h>

typedef struct FDNode {
    int fd;
    struct FDNode *next;
} FDNode;

static FDNode *fd_list = NULL;

int add_fd(int fd) {
    FDNode *node = malloc(sizeof(FDNode));
    if (!node) return -1;
    node->fd = fd;
    node->next = fd_list;
    fd_list = node;
    return 0;
}

int remove_fd(int fd) {
    FDNode *prev = NULL, *curr = fd_list;
    while (curr) {
        if (curr->fd == fd) {
            if (prev)
                prev->next = curr->next;
            else
                fd_list = curr->next;
            if (curr->fd >= 0)
                close(curr->fd);
            free(curr);
            return 0;
        }
        prev = curr;
        curr = curr->next;
    }
    return -1;
}

void cleanup_fds(void) {
    FDNode *curr = fd_list;
    while (curr) {
        FDNode *next = curr->next;
        if (curr->fd >= 0)
            close(curr->fd);
        free(curr);
        curr = next;
    }
    fd_list = NULL;
}

/* Example usage */
int main(void) {
    int fd1 = open("/dev/null", O_RDONLY);
    int fd2 = open("/dev/null", O_RDONLY);
    if (fd1 < 0 || fd2 < 0) {
        perror("open");
        return 1;
    }

    add_fd(fd1);
    add_fd(fd2);

    remove_fd(fd1);  /* Remove one handle */

    cleanup_fds();   /* First cleanup */
    cleanup_fds();   /* Second cleanup (safe) */

    return 0;
}