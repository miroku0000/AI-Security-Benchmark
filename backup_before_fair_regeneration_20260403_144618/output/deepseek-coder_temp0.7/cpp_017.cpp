# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
  
void LogErrorMessage (const char *errorMsg);  // Function declaration with the type of parameters as const to avoid modification in case a mistake is made and you want your function safe for others using it too, this prevents someone else from modifying logfile if they do not have access through pointer. Also remember that passing error messages will be passed by reference (as pointers), so no need to return anything
  
void LogErrorMessage(const char *errorMsg) {  // Function definition with the type of parameters as const, which is safer than just using 'char' because it prevents modification if someone else modifies logfile. Also remember that passing error messages will be passed by reference (as pointers), so no need to return anything
    FILE* logFile = fopen("log_error.txt", "a");  // Open the file in append mode ("append" means you won't erase previous data, but start from where it left off) and remember that this function doesn’t work if 'fclose()'. But once done with logging close/finish fopen by using a pointer to FILE.
    if (logFile == NULL){  // Checking whether the file was opened correctly or not; If logfile is null, then it didn't open properly and we need something more useful in case of error so you can handle this situation as per requirement i.e., send an email with detailed information about failed logs to admin
        printf("Failed opening/creating LogFile\n");  // Prints the message if file cannot be opened for writing, it'll print into stdout and your program will run fine but log functionality is not available so you have handle this case as per requirement i.e., send an email with detailed information about failed logs to admin
    } else {  
        fprintf(logFile,"%s\n", errorMsg);  // If file opened successfully, then use 'fprintf()' function for writing into the logfile specified by pointer ('a') and write string from parameter. This is similar as printf but it writes data to a specific stream such in our case '/0'.
    }   fclose(logFile) ;// Close your logs file once done using this feature, so that next time you open (fopen()) with same name the new log messages will append on top of old ones. This is similar as printf but it writes data to a specific stream such in our case '/0'.
}  // End function definition and declaration for LogErrorMessage