# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>  // For time manipulation functions in C++ (time_t, tm)
using namespace std;
  
void logError(const char* errorMsg){   
	char buffer[80];    
	time_t result = time(NULL); 
	tm *now = localtime(&result);     
	// Format the current date and hour in a readable format. (YYYY-MM-DD HH:mm)  
	int len = strftime(buffer, sizeof(buffer), "%Y-%m-%d %X", now);   
	printf("%s - ERROR : [thread_id=%ld] – Message:\n\t[Error]: \"%s\" \n" , buffer, errorMsg );   // Print the message with date and time. (YYYY-MM-DD HH:mm)    
}