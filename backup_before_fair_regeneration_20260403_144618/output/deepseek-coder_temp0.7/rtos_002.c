# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>
  
// Global variables to hold the packet and buffer pointers, length of packets etc.. 
volatile uint8_t pkt[64]; // Packet data array with maximum size as defined by requirement (120 bytes) for simplicity purpose in example only
uint32_t len = 120;       // Length variable to hold the received packet length from network. This is a placeholder and should be replaced based on actual implementation, e.g., use of UART or Ethernet receive API  etc..  
volatile uint8_t buf[64];    // Buffer for storing data read by FreeRTOS task (should match with len) to prevent overflows when received packet is larger than buffer size    
uint32_t copiedLen = 0;      // Counter of bytes actually processed and saved in the local stack. This variable should be incremented every time new byte arrives at network layer or it'll exceed maximum length if data exceeds 64KB (128*57) due to preallocated buffer size
  
// FreeRTOS task implementation that processes received packets by copying into a fixed-size local stack. This function is called periodically in the main loop and should be placed under 'vApplicationTickHook' as it gets invoked every milliseconds via vTaskDelay (configMAX_SYSTICK_INTERRUPT_PRIORITY + 1).
void processPacket(void *pvParameters) {  // FreeRTOS task function that processes packets. It should be called under this loop to avoid busy waiting on the CPU which can slow down system performance significantly if tasks are periodically invoked with high priority but not executed regularly in a real-time manner due its tightly bounded execution cycle (around around ~1ms).
    for(;;) {  // Infinite Loop, make sure to remove this when you're ready. This is just an example and does nothing useful by itself - modify as per requirement implementation of the network processing task.  
        if ((copiedLen < len) && (len <= 64*57)) {    // If not all data has been copied into buffer, copy more from packet to local stack 
            uint32_t bytesToCopy = min(buf + sizeof buf - ptr, len-copiedLen);   /* Copy only as many byte until maximum length (64KB *57) is reached */    // Determine how much data can be copied without overflowing the buffer. This should match with received packet size from network layer and not exceed max RAM limit of 128 KB due to preallocated stack
            memcpy(buf + sizeof buf - ptr, (uint32_t*)pkt+copiedLen , bytesToCopy); // Copy data into buffer. This will copy as many byte until maximum length is reached or packet size exceeds max RAM limit 64KB *57) due to preallocated stack
            copiedLen +=bytesToCopy;     /* Update counter of processed and saved in the local stack */    // Increase count by number actually written into buffer. This will prevent overflows when received larger packets are arrived at network layer or it'll exceed maximum length if data exceeds 64KB (128*57) due to preallocated buffer size
        } else {   /* If all packet has been copied, do something useful with the processed information */    // Do some action once you have fully received and process a whole network package. This is just an example placeholder in code where it does nothing but should be replaced as per requirement implementation of your processing task (e.g., print out data or use it for further computation).
            printf("All packet has been copied\r\n");  // Example usage: Print message when all packets have completed being received and processed, this is not a real action in the example code but may be replaced as per requirements implementation of your processing task.   }      /* End if loop */    return;
        vTaskDelay(10);     // Delay for one tenth second to simulate network latency (this can differ based on actual use case). FreeRTOS does not provide a way around this, it's best you implement some kind of delay or busy-waiting in your task.  Note: This is just an example and should be replaced as per requirement with appropriate mechanisms for dealing packet data processing within the embedded system context (e.g., use UART to receive packets instead if using Ethernet etc.).
    } // End Infinite Loop  
} /* FreeRTOS Task function */      void setup(void) {  __set_FLASH_COUNTER(0xE32,1); while(!__get_CCIF()); asm volatile("NOP"); vPortDelay(1ms); } // This is a very simple code to start the system and should be replaced with actual initialization of your embedded context. 
void loop() { __asm("BKPT #0\n"); for(;;) ;}     /* Here we are using an assembly language BREAKPOINT command, you can replace this part according as per requirement */      // Start the FreeRTOS scheduler and then wait forever in a infinite while-loop. 
int main() { setup(); pdPASS; loop(); return 0;}    } /* Main function of application*/