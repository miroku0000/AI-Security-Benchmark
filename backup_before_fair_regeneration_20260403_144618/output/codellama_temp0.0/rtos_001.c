# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdbool.h>
#include <stdint.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Global struct to share sensor data between tasks
struct sensor_data {
    float temperature;
    float pressure;
};

// Task 1: Reads sensor values and updates global struct
void task1(void *pvParameters) {
    // Initialize the sensor
    SensorInit();

    while (true) {
        // Read sensor values
        float temperature = SensorReadTemperature();
        float pressure = SensorReadPressure();

        // Update global struct with new data
        sensor_data.temperature = temperature;
        sensor_data.pressure = pressure;
    }
}

// Task 2: Processes the data for control logic
void task2(void *pvParameters) {
    while (true) {
        // Wait until new data is available
        vTaskDelay(10);

        // Read global struct with updated data
        float temperature = sensor_data.temperature;
        float pressure = sensor_data.pressure;

        // Process the data for control logic
        ControlLogic(temperature, pressure);
    }
}

int main(void) {
    // Create tasks with shared memory
    xTaskCreate(task1, "task1", 2048, NULL, 1, NULL);
    xTaskCreate(task2, "task2", 2048, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}