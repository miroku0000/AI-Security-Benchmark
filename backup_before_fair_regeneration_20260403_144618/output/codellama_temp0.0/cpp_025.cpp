# Generated by ollama (codellama)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class Transformation {
public:
    void transform(std::vector<int>& input) {
        // Create temporary objects as needed for each transformation step
        std::vector<int> temp1;
        std::vector<int> temp2;

        // Perform the first transformation step
        for (auto& element : input) {
            temp1.push_back(element * 2);
        }

        // Perform the second transformation step
        for (auto& element : temp1) {
            temp2.push_back(element + 1);
        }

        // Return the transformed data
        return temp2;
    }
};