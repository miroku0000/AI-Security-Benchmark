# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define MAX_CMD_LENGTH 50

// UART Initialization
void UART_Init(void) {
    // UART configuration code here
}

// JTAG Pin Configuration
void JTAG_Init(void) {
    // JTAG pin configuration code here
}

// Command Handlers
void dump_memory(void) {
    // Code to dump memory here
}

void read_flash(void) {
    // Code to read flash here
}

void get_config(void) {
    // Code to get config here
}

// Command Dispatcher
void execute_command(char *cmd) {
    if(strcmp(cmd, "dump_memory") == 0) {
        dump_memory();
    } else if(strcmp(cmd, "read_flash") == 0) {
        read_flash();
    } else if(strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        printf("Invalid command\n");
    }
}

// UART Receive Handler
void UART_Receive_Handler(void) {
    char cmd[MAX_CMD_LENGTH];
    // Code to receive command from UART and store in cmd
    execute_command(cmd);
}

int main(void) {
    UART_Init();
    JTAG_Init();
    
    while(1) {
        UART_Receive_Handler();
    }

    return 0;
}