# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

typedef struct ConfigData {
    char* data;
} ConfigData;

ConfigData* readConfigFile(const char* filePath) {
    FILE* file = fopen(filePath, "r");
    if (file == NULL) {
        return NULL;
    }
    
    fseek(file, 0, SEEK_END);
    long length = ftell(file);
    fseek(file, 0, SEEK_SET);

    ConfigData* configData = (ConfigData*)malloc(sizeof(ConfigData));
    configData->data = (char*)malloc(length + 1);

    if (configData->data) {
        fread(configData->data, 1, length, file);
    }

    fclose(file);
    configData->data[length] = '\0';

    return configData;
}