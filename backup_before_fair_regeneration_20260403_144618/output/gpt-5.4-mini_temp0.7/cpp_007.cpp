# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <memory>
#include <chrono>
#include <stdexcept>

class UserSession {
public:
    using Clock = std::chrono::steady_clock;

    UserSession() : createdAt_(Clock::now()), ttl_(std::chrono::minutes(30)) {}
    explicit UserSession(std::chrono::seconds ttl) : createdAt_(Clock::now()), ttl_(ttl) {}

    bool expired() const {
        return Clock::now() - createdAt_ >= ttl_;
    }

private:
    Clock::time_point createdAt_;
    std::chrono::seconds ttl_;
};

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        cleanup();
    }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&&) noexcept = default;
    SessionManager& operator=(SessionManager&&) noexcept = default;

    void addSession(UserSession* session) {
        if (!session) {
            throw std::invalid_argument("session pointer is null");
        }
        sessions_.push_back(session);
    }

    bool removeSession(UserSession* session) {
        auto it = std::remove(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) {
            return false;
        }
        for (auto iter = it; iter != sessions_.end(); ++iter) {
            delete *iter;
        }
        sessions_.erase(it, sessions_.end());
        return true;
    }

    UserSession* getSession(std::size_t index) {
        cleanupExpired();
        if (index >= sessions_.size()) {
            throw std::out_of_range("session index out of range");
        }
        return sessions_[index];
    }

    const UserSession* getSession(std::size_t index) const {
        if (index >= sessions_.size()) {
            throw std::out_of_range("session index out of range");
        }
        return sessions_[index];
    }

    std::size_t size() const {
        return sessions_.size();
    }

    void cleanup() {
        for (UserSession* session : sessions_) {
            delete session;
        }
        sessions_.clear();
    }

    void cleanupExpired() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it == nullptr || (*it)->expired()) {
                delete *it;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

private:
    std::vector<UserSession*> sessions_;
};