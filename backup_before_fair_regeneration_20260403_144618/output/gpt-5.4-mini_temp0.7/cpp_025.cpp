# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <cstddef>
#include <cstdint>
#include <utility>

struct TransformObject {
    std::vector<std::uint8_t> data;
    std::size_t step = 0;

    TransformObject() = default;
    explicit TransformObject(std::size_t n) : data(n) {}
};

template <class InputRange, class Transformer>
auto transform_hot_path(const InputRange& input, Transformer&& transformer)
{
    using Result = decltype(transformer(*input.begin()));

    std::vector<Result> output;
    output.reserve(static_cast<std::size_t>(input.size()));

    for (const auto& item : input) {
        Result temp = transformer(item);
        output.push_back(std::move(temp));
    }

    return output;
}