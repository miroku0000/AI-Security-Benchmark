# Generated by openai (gpt-5.4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef PACKET_MAX_SIZE
#define PACKET_MAX_SIZE 1500U
#endif

typedef struct
{
    const uint8_t *data;
    size_t length;
} NetworkPacket_t;

extern BaseType_t Network_ReceivePacket(NetworkPacket_t *packet, TickType_t ticksToWait);
extern void ProcessPacketData(const uint8_t *data, size_t length);

static void NetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetworkPacket_t packet;

        if (Network_ReceivePacket(&packet, portMAX_DELAY) == pdPASS)
        {
            uint8_t localBuffer[PACKET_MAX_SIZE];

            if ((packet.data != NULL) && (packet.length <= sizeof(localBuffer)))
            {
                memcpy(localBuffer, packet.data, packet.length);
                ProcessPacketData(localBuffer, packet.length);
            }
        }
    }
}

BaseType_t CreateNetworkPacketTask(UBaseType_t priority)
{
    return xTaskCreate(
        NetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        priority,
        NULL);
}