# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <string>
#include <chrono>
#include <iomanip>

class Bank {
public:
    void addAccount(int id, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        accounts_[id] = initialBalance;
    }

    bool deposit(int id, double amount) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || amount < 0.0) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(int id, double amount) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || amount < 0.0 || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(int fromId, int toId, double amount) {
        if (fromId == toId || amount < 0.0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto fromIt = accounts_.find(fromId);
        auto toIt = accounts_.find(toId);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    bool getBalance(int id, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    void printAllAccounts() const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex_);
        std::cout << "\nFinal account balances:\n";
        for (const auto& [id, balance] : accounts_) {
            std::cout << "Account " << id << ": $" << std::fixed << std::setprecision(2) << balance << '\n';
        }
    }

private:
    mutable std::shared_mutex accountsMutex_;
    std::unordered_map<int, double> accounts_;
};

void transactionWorker(Bank& bank, const std::vector<int>& accountIds, int workerId, int operations) {
    std::mt19937 rng(std::random_device{}() + workerId);
    std::uniform_int_distribution<int> accountDist(0, static_cast<int>(accountIds.size()) - 1);
    std::uniform_real_distribution<double> amountDist(1.0, 500.0);
    std::uniform_int_distribution<int> opDist(0, 3);

    for (int i = 0; i < operations; ++i) {
        int op = opDist(rng);
        int acc1 = accountIds[accountDist(rng)];
        int acc2 = accountIds[accountDist(rng)];
        double amount = amountDist(rng);

        switch (op) {
            case 0:
                bank.deposit(acc1, amount);
                break;
            case 1:
                bank.withdraw(acc1, amount);
                break;
            case 2:
                bank.transfer(acc1, acc2, amount);
                break;
            case 3: {
                double balance = 0.0;
                bank.getBalance(acc1, balance);
                break;
            }
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(5));
    }
}

int main() {
    Bank bank;

    const int numAccounts = 10;
    const int numThreads = 6;
    const int operationsPerThread = 100;

    std::vector<int> accountIds;
    accountIds.reserve(numAccounts);

    for (int i = 1; i <= numAccounts; ++i) {
        bank.addAccount(i, 1000.0);
        accountIds.push_back(i);
    }

    std::vector<std::thread> threads;
    threads.reserve(numThreads);

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(transactionWorker, std::ref(bank), std::cref(accountIds), i, operationsPerThread);
    }

    for (auto& t : threads) {
        t.join();
    }

    bank.printAllAccounts();

    return 0;
}