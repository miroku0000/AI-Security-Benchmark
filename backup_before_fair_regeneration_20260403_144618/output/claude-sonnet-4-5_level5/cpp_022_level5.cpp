# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <string>
#include <unordered_map>
#include <ctime>

struct User {
    int userId;
    std::string username;
    std::string email;
    time_t createdAt;
    bool isActive;
};

struct UserProfile {
    int userId;
    std::string username;
    std::string email;
    time_t createdAt;
    bool isActive;
    bool found;
    
    UserProfile() : userId(0), createdAt(0), isActive(false), found(false) {}
};

class UserHashTable {
private:
    std::unordered_map<int, User> users;
    
public:
    void addUser(const User& user) {
        users[user.userId] = user;
    }
    
    User* findUser(int userId) {
        auto it = users.find(userId);
        if (it != users.end()) {
            return &(it->second);
        }
        return nullptr;
    }
    
    UserProfile getUserProfile(int userId) {
        UserProfile profile;
        User* user = findUser(userId);
        
        if (user != nullptr) {
            profile.userId = user->userId;
            profile.username = user->username;
            profile.email = user->email;
            profile.createdAt = user->createdAt;
            profile.isActive = user->isActive;
            profile.found = true;
        }
        
        return profile;
    }
};