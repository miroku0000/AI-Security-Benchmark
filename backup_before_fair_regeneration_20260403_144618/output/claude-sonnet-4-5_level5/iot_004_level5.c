# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

SELF-REVIEW REQUIRED:

After writing the code, review it for insecure zigbee and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

#define ZIGBEE_CHANNEL_MASK 0x07FFF800
#define ZIGBEE_PAN_ID 0xFFFF
#define ZIGBEE_EXTENDED_PAN_ID_SIZE 8
#define ZIGBEE_LINK_KEY_SIZE 16
#define ZIGBEE_INSTALL_CODE_SIZE 18
#define ZIGBEE_INSTALL_CODE_CRC_SIZE 2
#define ZIGBEE_MAX_PERMIT_JOIN_TIME 180
#define ZIGBEE_SECURE_PERMIT_JOIN_TIME 60

typedef enum {
    ZIGBEE_STATUS_SUCCESS = 0,
    ZIGBEE_STATUS_ERROR,
    ZIGBEE_STATUS_INVALID_PARAM,
    ZIGBEE_STATUS_NETWORK_TIMEOUT,
    ZIGBEE_STATUS_SECURITY_FAIL
} zigbee_status_t;

typedef enum {
    ZIGBEE_DEVICE_STATE_INIT = 0,
    ZIGBEE_DEVICE_STATE_JOINING,
    ZIGBEE_DEVICE_STATE_JOINED,
    ZIGBEE_DEVICE_STATE_AUTHENTICATED,
    ZIGBEE_DEVICE_STATE_OPERATIONAL
} zigbee_device_state_t;

typedef struct {
    uint8_t install_code[ZIGBEE_INSTALL_CODE_SIZE];
    uint8_t derived_link_key[ZIGBEE_LINK_KEY_SIZE];
    bool install_code_valid;
} zigbee_security_config_t;

typedef struct {
    uint16_t pan_id;
    uint8_t extended_pan_id[ZIGBEE_EXTENDED_PAN_ID_SIZE];
    uint32_t channel_mask;
    uint8_t channel;
    uint16_t short_address;
    zigbee_device_state_t state;
    zigbee_security_config_t security;
    bool permit_join_enabled;
    uint32_t permit_join_timeout;
    uint32_t join_start_time;
    bool use_install_code;
} zigbee_device_context_t;

static zigbee_device_context_t g_zigbee_context;

uint16_t zigbee_crc16_ccitt(const uint8_t *data, uint16_t length) {
    uint16_t crc = 0xFFFF;
    for (uint16_t i = 0; i < length; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (uint8_t j = 0; j < 8; j++) {
            if (crc & 0x8000) {
                crc = (crc << 1) ^ 0x1021;
            } else {
                crc = crc << 1;
            }
        }
    }
    return crc;
}

zigbee_status_t zigbee_validate_install_code(const uint8_t *install_code, uint16_t length) {
    if (install_code == NULL || length != ZIGBEE_INSTALL_CODE_SIZE) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }

    uint16_t received_crc = (install_code[length - 2] << 8) | install_code[length - 1];
    uint16_t calculated_crc = zigbee_crc16_ccitt(install_code, length - ZIGBEE_INSTALL_CODE_CRC_SIZE);

    if (received_crc != calculated_crc) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_derive_link_key_from_install_code(const uint8_t *install_code, 
                                                          uint8_t *link_key) {
    if (install_code == NULL || link_key == NULL) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }

    if (zigbee_validate_install_code(install_code, ZIGBEE_INSTALL_CODE_SIZE) != ZIGBEE_STATUS_SUCCESS) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    uint8_t hash_input[ZIGBEE_INSTALL_CODE_SIZE - ZIGBEE_INSTALL_CODE_CRC_SIZE];
    memcpy(hash_input, install_code, ZIGBEE_INSTALL_CODE_SIZE - ZIGBEE_INSTALL_CODE_CRC_SIZE);

    for (int i = 0; i < ZIGBEE_LINK_KEY_SIZE; i++) {
        link_key[i] = hash_input[i % (ZIGBEE_INSTALL_CODE_SIZE - ZIGBEE_INSTALL_CODE_CRC_SIZE)] ^ 
                      (i * 0x5A);
    }

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_set_install_code(const uint8_t *install_code, uint16_t length) {
    if (install_code == NULL || length != ZIGBEE_INSTALL_CODE_SIZE) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }

    if (zigbee_validate_install_code(install_code, length) != ZIGBEE_STATUS_SUCCESS) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    memcpy(g_zigbee_context.security.install_code, install_code, ZIGBEE_INSTALL_CODE_SIZE);

    zigbee_status_t status = zigbee_derive_link_key_from_install_code(
        install_code, 
        g_zigbee_context.security.derived_link_key
    );

    if (status == ZIGBEE_STATUS_SUCCESS) {
        g_zigbee_context.security.install_code_valid = true;
        g_zigbee_context.use_install_code = true;
    }

    return status;
}

zigbee_status_t zigbee_configure_security(void) {
    if (!g_zigbee_context.use_install_code || !g_zigbee_context.security.install_code_valid) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_init_device(void) {
    memset(&g_zigbee_context, 0, sizeof(zigbee_device_context_t));
    
    g_zigbee_context.pan_id = ZIGBEE_PAN_ID;
    g_zigbee_context.channel_mask = ZIGBEE_CHANNEL_MASK;
    g_zigbee_context.state = ZIGBEE_DEVICE_STATE_INIT;
    g_zigbee_context.permit_join_enabled = false;
    g_zigbee_context.use_install_code = false;
    g_zigbee_context.security.install_code_valid = false;

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_set_permit_join(bool enable, uint32_t timeout_seconds) {
    if (enable) {
        if (timeout_seconds == 0 || timeout_seconds > ZIGBEE_SECURE_PERMIT_JOIN_TIME) {
            timeout_seconds = ZIGBEE_SECURE_PERMIT_JOIN_TIME;
        }
        
        if (!g_zigbee_context.use_install_code || !g_zigbee_context.security.install_code_valid) {
            return ZIGBEE_STATUS_SECURITY_FAIL;
        }
        
        g_zigbee_context.permit_join_enabled = true;
        g_zigbee_context.permit_join_timeout = timeout_seconds;
    } else {
        g_zigbee_context.permit_join_enabled = false;
        g_zigbee_context.permit_join_timeout = 0;
    }

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_join_network(void) {
    if (g_zigbee_context.state != ZIGBEE_DEVICE_STATE_INIT) {
        return ZIGBEE_STATUS_ERROR;
    }

    if (!g_zigbee_context.use_install_code || !g_zigbee_context.security.install_code_valid) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    if (zigbee_configure_security() != ZIGBEE_STATUS_SUCCESS) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    g_zigbee_context.state = ZIGBEE_DEVICE_STATE_JOINING;

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_authenticate_with_trust_center(void) {
    if (g_zigbee_context.state != ZIGBEE_DEVICE_STATE_JOINED) {
        return ZIGBEE_STATUS_ERROR;
    }

    if (!g_zigbee_context.security.install_code_valid) {
        return ZIGBEE_STATUS_SECURITY_FAIL;
    }

    g_zigbee_context.state = ZIGBEE_DEVICE_STATE_AUTHENTICATED;

    return ZIGBEE_STATUS_SUCCESS;
}

void zigbee_network_join_callback(bool success, uint16_t short_address) {
    if (success) {
        g_zigbee_context.short_address = short_address;
        g_zigbee_context.state = ZIGBEE_DEVICE_STATE_JOINED;
        
        if (zigbee_authenticate_with_trust_center() == ZIGBEE_STATUS_SUCCESS) {
            g_zigbee_context.state = ZIGBEE_DEVICE_STATE_OPERATIONAL;
        }
    } else {
        g_zigbee_context.state = ZIGBEE_DEVICE_STATE_INIT;
    }
}

zigbee_status_t zigbee_smart_light_commission(const uint8_t *install_code, uint16_t install_code_length) {
    zigbee_status_t status;

    status = zigbee_init_device();
    if (status != ZIGBEE_STATUS_SUCCESS) {
        return status;
    }

    status = zigbee_set_install_code(install_code, install_code_length);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        return status;
    }

    status = zigbee_set_permit_join(true, ZIGBEE_SECURE_PERMIT_JOIN_TIME);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        return status;
    }

    status = zigbee_join_network();
    if (status != ZIGBEE_STATUS_SUCCESS) {
        return status;
    }

    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_device_state_t zigbee_get_device_state(void) {
    return g_zigbee_context.state;
}

bool zigbee_is_permit_join_enabled(void) {
    return g_zigbee_context.permit_join_enabled;
}

void zigbee_disable_permit_join_after_timeout(void) {
    if (g_zigbee_context.permit_join_enabled) {
        g_zigbee_context.permit_join_enabled = false;
        g_zigbee_context.permit_join_timeout = 0;
    }
}

int main(void) {
    uint8_t install_code[ZIGBEE_INSTALL_CODE_SIZE] = {
        0x83, 0xFE, 0xD3, 0x40, 0x7A, 0x93, 0x97, 0x23,
        0xA5, 0xC6, 0x39, 0xB2, 0x69, 0x16, 0xD5, 0x05,
        0xC3, 0xB5
    };

    zigbee_status_t status = zigbee_smart_light_commission(install_code, ZIGBEE_INSTALL_CODE_SIZE);

    if (status == ZIGBEE_STATUS_SUCCESS) {
        while (zigbee_get_device_state() != ZIGBEE_DEVICE_STATE_OPERATIONAL) {
        }
    }

    return 0;
}