# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory corruption and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdint.h>

#define MAX_COMMAND_LENGTH 128
#define MAX_PARAM_LENGTH 64

typedef struct {
    uint8_t sensor_enabled;
    uint16_t sample_rate;
    uint8_t tx_power;
    char device_name[MAX_PARAM_LENGTH];
} DeviceConfig;

static DeviceConfig config = {
    .sensor_enabled = 1,
    .sample_rate = 1000,
    .tx_power = 10,
    .device_name = "IoT_Sensor_01"
};

void apply_config_command(const char *command) {
    char cmd_type[MAX_PARAM_LENGTH];
    char param[MAX_PARAM_LENGTH];
    
    if (sscanf(command, "%63s %63s", cmd_type, param) < 1) {
        printf("Invalid command format\n");
        return;
    }
    
    if (strcmp(cmd_type, "ENABLE") == 0) {
        config.sensor_enabled = 1;
        printf("Sensor enabled\n");
    }
    else if (strcmp(cmd_type, "DISABLE") == 0) {
        config.sensor_enabled = 0;
        printf("Sensor disabled\n");
    }
    else if (strcmp(cmd_type, "RATE") == 0) {
        int rate = atoi(param);
        if (rate > 0 && rate <= 10000) {
            config.sample_rate = (uint16_t)rate;
            printf("Sample rate set to %d\n", config.sample_rate);
        } else {
            printf("Invalid rate value\n");
        }
    }
    else if (strcmp(cmd_type, "POWER") == 0) {
        int power = atoi(param);
        if (power >= 0 && power <= 20) {
            config.tx_power = (uint8_t)power;
            printf("TX power set to %d\n", config.tx_power);
        } else {
            printf("Invalid power value\n");
        }
    }
    else if (strcmp(cmd_type, "NAME") == 0) {
        size_t param_len = strlen(param);
        if (param_len > 0 && param_len < MAX_PARAM_LENGTH) {
            strncpy(config.device_name, param, MAX_PARAM_LENGTH - 1);
            config.device_name[MAX_PARAM_LENGTH - 1] = '\0';
            printf("Device name set to %s\n", config.device_name);
        } else {
            printf("Invalid name length\n");
        }
    }
    else if (strcmp(cmd_type, "STATUS") == 0) {
        printf("Device Status:\n");
        printf("  Enabled: %d\n", config.sensor_enabled);
        printf("  Sample Rate: %d Hz\n", config.sample_rate);
        printf("  TX Power: %d dBm\n", config.tx_power);
        printf("  Name: %s\n", config.device_name);
    }
    else {
        printf("Unknown command: %s\n", cmd_type);
    }
}

void process_serial_input(void) {
    char command_buffer[MAX_COMMAND_LENGTH];
    size_t bytes_read = 0;
    int c;
    
    printf("IoT Device Configuration System\n");
    printf("Commands: ENABLE, DISABLE, RATE <value>, POWER <value>, NAME <name>, STATUS\n");
    printf("> ");
    fflush(stdout);
    
    while (1) {
        c = getchar();
        
        if (c == EOF) {
            break;
        }
        
        if (c == '\n' || c == '\r') {
            if (bytes_read > 0) {
                command_buffer[bytes_read] = '\0';
                apply_config_command(command_buffer);
                bytes_read = 0;
                printf("> ");
                fflush(stdout);
            }
        }
        else {
            if (bytes_read < MAX_COMMAND_LENGTH - 1) {
                command_buffer[bytes_read++] = (char)c;
            } else {
                printf("\nCommand too long, discarding\n");
                while ((c = getchar()) != '\n' && c != '\r' && c != EOF);
                bytes_read = 0;
                printf("> ");
                fflush(stdout);
            }
        }
    }
}

int main(void) {
    process_serial_input();
    return 0;
}