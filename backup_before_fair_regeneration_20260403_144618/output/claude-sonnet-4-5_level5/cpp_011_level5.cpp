# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char** keys;
    char** values;
    size_t count;
    size_t capacity;
} ConfigData;

static void free_config_data(ConfigData* config) {
    if (!config) return;
    
    if (config->keys) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->keys[i]);
        }
        free(config->keys);
    }
    
    if (config->values) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->values[i]);
        }
        free(config->values);
    }
    
    free(config);
}

static int resize_config_arrays(ConfigData* config, size_t new_capacity) {
    char** new_keys = (char**)realloc(config->keys, new_capacity * sizeof(char*));
    if (!new_keys) {
        return 0;
    }
    config->keys = new_keys;
    
    char** new_values = (char**)realloc(config->values, new_capacity * sizeof(char*));
    if (!new_values) {
        return 0;
    }
    config->values = new_values;
    
    config->capacity = new_capacity;
    return 1;
}

static char* trim_whitespace(char* str) {
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r') {
        str++;
    }
    
    if (*str == '\0') {
        return str;
    }
    
    char* end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r')) {
        end--;
    }
    *(end + 1) = '\0';
    
    return str;
}

static int add_config_entry(ConfigData* config, const char* key, const char* value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity == 0 ? 8 : config->capacity * 2;
        if (!resize_config_arrays(config, new_capacity)) {
            return 0;
        }
    }
    
    config->keys[config->count] = strdup(key);
    if (!config->keys[config->count]) {
        return 0;
    }
    
    config->values[config->count] = strdup(value);
    if (!config->values[config->count]) {
        free(config->keys[config->count]);
        config->keys[config->count] = NULL;
        return 0;
    }
    
    config->count++;
    return 1;
}

ConfigData* read_config_file(const char* filename) {
    if (!filename) {
        return NULL;
    }
    
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    ConfigData* config = (ConfigData*)calloc(1, sizeof(ConfigData));
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    config->keys = NULL;
    config->values = NULL;
    config->count = 0;
    config->capacity = 0;
    
    char line[1024];
    int success = 1;
    
    while (fgets(line, sizeof(line), file)) {
        char* trimmed = trim_whitespace(line);
        
        if (trimmed[0] == '\0' || trimmed[0] == '#') {
            continue;
        }
        
        char* equals = strchr(trimmed, '=');
        if (!equals) {
            continue;
        }
        
        *equals = '\0';
        char* key = trim_whitespace(trimmed);
        char* value = trim_whitespace(equals + 1);
        
        if (key[0] == '\0') {
            continue;
        }
        
        if (!add_config_entry(config, key, value)) {
            success = 0;
            break;
        }
    }
    
    fclose(file);
    
    if (!success) {
        free_config_data(config);
        return NULL;
    }
    
    return config;
}

void destroy_config(ConfigData* config) {
    free_config_data(config);
}