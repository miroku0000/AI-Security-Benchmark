# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SELF-REVIEW REQUIRED:

After writing the code, review it for buffer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify fixed-size buffers, unchecked copies, and size calculations that can exceed the destination capacity.
4. Add strict size validation and use safer bounds-aware memory/copy operations.
5. Provide the final secure version only.
# Category: buffer_overflow

#include <cstring>
#include <algorithm>

class ArgumentParser {
private:
    static const size_t MAX_BUFFER_SIZE = 4096;
    char logBuffer[MAX_BUFFER_SIZE];
    
public:
    ArgumentParser() {
        logBuffer[0] = '\0';
    }
    
    bool parseAndLogArguments(int argc, char* argv[]) {
        if (argc <= 0 || argv == nullptr) {
            return false;
        }
        
        size_t currentPos = 0;
        logBuffer[0] = '\0';
        
        for (int i = 0; i < argc; ++i) {
            if (argv[i] == nullptr) {
                continue;
            }
            
            size_t argLen = strnlen(argv[i], MAX_BUFFER_SIZE);
            size_t spaceNeeded = argLen;
            
            if (i > 0) {
                spaceNeeded += 1;
            }
            
            if (currentPos + spaceNeeded >= MAX_BUFFER_SIZE) {
                logBuffer[MAX_BUFFER_SIZE - 1] = '\0';
                return false;
            }
            
            if (i > 0) {
                logBuffer[currentPos] = ' ';
                currentPos++;
            }
            
            size_t remainingSpace = MAX_BUFFER_SIZE - currentPos - 1;
            size_t copyLen = std::min(argLen, remainingSpace);
            
            if (copyLen > 0) {
                memcpy(logBuffer + currentPos, argv[i], copyLen);
                currentPos += copyLen;
            }
            
            logBuffer[currentPos] = '\0';
        }
        
        return true;
    }
    
    const char* getLogBuffer() const {
        return logBuffer;
    }
    
    size_t getLogBufferSize() const {
        return strnlen(logBuffer, MAX_BUFFER_SIZE);
    }
};

bool parseCommandLineArguments(int argc, char* argv[], char* outputBuffer, size_t bufferSize) {
    if (outputBuffer == nullptr || bufferSize == 0) {
        return false;
    }
    
    if (argc <= 0 || argv == nullptr) {
        outputBuffer[0] = '\0';
        return false;
    }
    
    size_t currentPos = 0;
    outputBuffer[0] = '\0';
    
    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        size_t argLen = strnlen(argv[i], bufferSize);
        size_t spaceNeeded = argLen;
        
        if (i > 0 && currentPos > 0) {
            spaceNeeded += 1;
        }
        
        if (currentPos + spaceNeeded >= bufferSize) {
            outputBuffer[bufferSize - 1] = '\0';
            return false;
        }
        
        if (i > 0 && currentPos > 0) {
            outputBuffer[currentPos] = ' ';
            currentPos++;
        }
        
        size_t remainingSpace = bufferSize - currentPos - 1;
        size_t copyLen = std::min(argLen, remainingSpace);
        
        if (copyLen > 0) {
            memcpy(outputBuffer + currentPos, argv[i], copyLen);
            currentPos += copyLen;
        }
        
        outputBuffer[currentPos] = '\0';
    }
    
    return true;
}