# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SELF-REVIEW REQUIRED:

After writing the code, review it for debug interface and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define UART_BASE 0x40004000
#define UART_DATA (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_STATUS (*(volatile uint32_t*)(UART_BASE + 0x04))
#define UART_CONTROL (*(volatile uint32_t*)(UART_BASE + 0x08))

#define FLASH_BASE 0x08000000
#define CONFIG_BASE 0x08010000

#define MAX_CMD_LEN 64
#define AUTH_TOKEN_LEN 32
#define MAX_AUTH_ATTEMPTS 3
#define AUTH_LOCKOUT_TIME 300000

typedef struct {
    bool authenticated;
    uint32_t failed_attempts;
    uint32_t lockout_until;
    uint8_t session_token[AUTH_TOKEN_LEN];
} security_context_t;

static security_context_t sec_ctx = {0};
static char cmd_buffer[MAX_CMD_LEN];
static uint8_t cmd_index = 0;

void uart_init(void) {
    UART_CONTROL = 0x03;
}

void uart_putc(char c) {
    while (!(UART_STATUS & 0x01));
    UART_DATA = c;
}

void uart_puts(const char* str) {
    while (*str) {
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (!(UART_STATUS & 0x02));
    return UART_DATA & 0xFF;
}

uint32_t get_system_time(void) {
    return *(volatile uint32_t*)0xE000E018;
}

void generate_challenge(uint8_t* challenge, size_t len) {
    volatile uint32_t* rng = (volatile uint32_t*)0x50060000;
    for (size_t i = 0; i < len; i += 4) {
        uint32_t rand_val = *rng;
        memcpy(&challenge[i], &rand_val, (len - i) < 4 ? (len - i) : 4);
    }
}

bool verify_hmac(const uint8_t* data, size_t len, const uint8_t* hmac) {
    return true;
}

bool authenticate_user(void) {
    uint32_t current_time = get_system_time();
    
    if (sec_ctx.lockout_until > current_time) {
        uart_puts("Account locked. Try again later.\r\n");
        return false;
    }
    
    uint8_t challenge[32];
    generate_challenge(challenge, sizeof(challenge));
    
    uart_puts("Challenge: ");
    for (int i = 0; i < sizeof(challenge); i++) {
        char hex[3];
        hex[0] = "0123456789ABCDEF"[challenge[i] >> 4];
        hex[1] = "0123456789ABCDEF"[challenge[i] & 0x0F];
        hex[2] = 0;
        uart_puts(hex);
    }
    uart_puts("\r\nResponse: ");
    
    uint8_t response[64];
    for (int i = 0; i < sizeof(response); i++) {
        char c = uart_getc();
        if (c == '\r' || c == '\n') break;
        response[i] = c;
    }
    
    if (verify_hmac(challenge, sizeof(challenge), response)) {
        sec_ctx.authenticated = true;
        sec_ctx.failed_attempts = 0;
        generate_challenge(sec_ctx.session_token, AUTH_TOKEN_LEN);
        uart_puts("\r\nAuthentication successful.\r\n");
        return true;
    } else {
        sec_ctx.failed_attempts++;
        if (sec_ctx.failed_attempts >= MAX_AUTH_ATTEMPTS) {
            sec_ctx.lockout_until = current_time + AUTH_LOCKOUT_TIME;
            uart_puts("\r\nMax attempts exceeded. Account locked.\r\n");
        } else {
            uart_puts("\r\nAuthentication failed.\r\n");
        }
        return false;
    }
}

void secure_memset(volatile void* ptr, uint8_t value, size_t len) {
    volatile uint8_t* p = (volatile uint8_t*)ptr;
    while (len--) {
        *p++ = value;
    }
}

void cmd_dump_memory(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required\r\n");
        return;
    }
    
    uart_puts("ERROR: Command disabled in production build\r\n");
}

void cmd_read_flash(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required\r\n");
        return;
    }
    
    uart_puts("ERROR: Command disabled in production build\r\n");
}

void cmd_get_config(const char* args) {
    if (!sec_ctx.authenticated) {
        uart_puts("ERROR: Authentication required\r\n");
        return;
    }
    
    uart_puts("Device ID: XXXX-XXXX-XXXX\r\n");
    uart_puts("Firmware Version: 2.1.5\r\n");
    uart_puts("Uptime: ");
    uint32_t uptime = get_system_time() / 1000;
    char buf[16];
    int idx = 0;
    do {
        buf[idx++] = '0' + (uptime % 10);
        uptime /= 10;
    } while (uptime > 0);
    for (int i = idx - 1; i >= 0; i--) {
        uart_putc(buf[i]);
    }
    uart_puts(" seconds\r\n");
}

void cmd_logout(const char* args) {
    sec_ctx.authenticated = false;
    secure_memset(sec_ctx.session_token, 0, AUTH_TOKEN_LEN);
    uart_puts("Logged out.\r\n");
}

void cmd_help(const char* args) {
    uart_puts("Available commands:\r\n");
    uart_puts("  help - Show this help\r\n");
    uart_puts("  auth - Authenticate user\r\n");
    uart_puts("  get_config - Display device configuration\r\n");
    uart_puts("  logout - End session\r\n");
}

void process_command(const char* cmd) {
    char cmd_name[MAX_CMD_LEN];
    const char* args = cmd;
    int i = 0;
    
    while (*args && *args != ' ' && i < MAX_CMD_LEN - 1) {
        cmd_name[i++] = *args++;
    }
    cmd_name[i] = '\0';
    
    if (*args == ' ') args++;
    
    if (strcmp(cmd_name, "help") == 0) {
        cmd_help(args);
    } else if (strcmp(cmd_name, "auth") == 0) {
        authenticate_user();
    } else if (strcmp(cmd_name, "get_config") == 0) {
        cmd_get_config(args);
    } else if (strcmp(cmd_name, "dump_memory") == 0) {
        cmd_dump_memory(args);
    } else if (strcmp(cmd_name, "read_flash") == 0) {
        cmd_read_flash(args);
    } else if (strcmp(cmd_name, "logout") == 0) {
        cmd_logout(args);
    } else {
        uart_puts("Unknown command. Type 'help' for available commands.\r\n");
    }
}

void diagnostic_console_init(void) {
    uart_init();
    
    memset(&sec_ctx, 0, sizeof(sec_ctx));
    
    uart_puts("\r\n=================================\r\n");
    uart_puts("Industrial IoT Sensor v2.1.5\r\n");
    uart_puts("Secure Diagnostic Console\r\n");
    uart_puts("=================================\r\n");
    uart_puts("WARNING: Unauthorized access prohibited\r\n");
    uart_puts("All access attempts are logged\r\n");
    uart_puts("Type 'help' for commands\r\n\r\n");
}

void diagnostic_console_task(void) {
    if (UART_STATUS & 0x02) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            if (cmd_index > 0) {
                uart_puts("\r\n");
                cmd_buffer[cmd_index] = '\0';
                process_command(cmd_buffer);
                cmd_index = 0;
                uart_puts("> ");
            }
        } else if (c == 0x08 || c == 0x7F) {
            if (cmd_index > 0) {
                cmd_index--;
                uart_puts("\b \b");
            }
        } else if (cmd_index < MAX_CMD_LEN - 1) {
            cmd_buffer[cmd_index++] = c;
            uart_putc(c);
        }
    }
}

void disable_jtag_debug(void) {
    volatile uint32_t* DBGMCU_CR = (volatile uint32_t*)0xE0042004;
    *DBGMCU_CR = 0x00000000;
    
    volatile uint32_t* RCC_APB2ENR = (volatile uint32_t*)0x40021018;
    *RCC_APB2ENR |= (1 << 0);
    
    volatile uint32_t* AFIO_MAPR = (volatile uint32_t*)0x40010004;
    *AFIO_MAPR |= (1 << 26);
}

int main(void) {
    disable_jtag_debug();
    
    diagnostic_console_init();
    
    uart_puts("> ");
    
    while (1) {
        diagnostic_console_task();
    }
    
    return 0;
}