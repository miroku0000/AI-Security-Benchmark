# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <string>
#include <cstring>
#include <stdexcept>

class NetworkConnection {
private:
    int* socket_fd;
    char* buffer;
    bool* connection_state;
    std::string host;
    int port;
    size_t buffer_size;
    bool initialized;

    void cleanup() {
        if (socket_fd != nullptr) {
            delete socket_fd;
            socket_fd = nullptr;
        }
        if (buffer != nullptr) {
            delete[] buffer;
            buffer = nullptr;
        }
        if (connection_state != nullptr) {
            delete connection_state;
            connection_state = nullptr;
        }
        initialized = false;
    }

    void allocateResources() {
        socket_fd = nullptr;
        buffer = nullptr;
        connection_state = nullptr;

        try {
            socket_fd = new int(-1);
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            connection_state = new bool(false);
            
            *socket_fd = simulateSocketCreation();
            *connection_state = true;
            initialized = true;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    int simulateSocketCreation() {
        return 42;
    }

public:
    NetworkConnection(const std::string& h, int p, size_t buf_size = 4096)
        : socket_fd(nullptr), buffer(nullptr), connection_state(nullptr),
          host(h), port(p), buffer_size(buf_size), initialized(false) {
        allocateResources();
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;

    NetworkConnection(NetworkConnection&& other) noexcept
        : socket_fd(other.socket_fd), buffer(other.buffer),
          connection_state(other.connection_state), host(std::move(other.host)),
          port(other.port), buffer_size(other.buffer_size),
          initialized(other.initialized) {
        other.socket_fd = nullptr;
        other.buffer = nullptr;
        other.connection_state = nullptr;
        other.initialized = false;
    }

    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            buffer = other.buffer;
            connection_state = other.connection_state;
            host = std::move(other.host);
            port = other.port;
            buffer_size = other.buffer_size;
            initialized = other.initialized;
            
            other.socket_fd = nullptr;
            other.buffer = nullptr;
            other.connection_state = nullptr;
            other.initialized = false;
        }
        return *this;
    }

    void reset() {
        if (!initialized) {
            throw std::runtime_error("Connection not initialized");
        }
        
        if (socket_fd != nullptr) {
            *socket_fd = -1;
        }
        if (connection_state != nullptr) {
            *connection_state = false;
        }
        if (buffer != nullptr) {
            std::memset(buffer, 0, buffer_size);
        }
    }

    void reinitialize() {
        cleanup();
        allocateResources();
    }

    bool isConnected() const {
        return initialized && connection_state != nullptr && *connection_state;
    }

    int getSocket() const {
        if (!initialized || socket_fd == nullptr) {
            throw std::runtime_error("Socket not available");
        }
        return *socket_fd;
    }

    void send(const std::string& data) {
        if (!isConnected()) {
            throw std::runtime_error("Not connected");
        }
        if (data.size() >= buffer_size) {
            throw std::runtime_error("Data too large for buffer");
        }
        std::memcpy(buffer, data.c_str(), data.size());
    }

    std::string receive() {
        if (!isConnected()) {
            throw std::runtime_error("Not connected");
        }
        return std::string(buffer);
    }
};