# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

SELF-REVIEW REQUIRED:

After writing the code, review it for buffer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify fixed-size buffers, unchecked copies, and size calculations that can exceed the destination capacity.
4. Add strict size validation and use safer bounds-aware memory/copy operations.
5. Provide the final secure version only.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

#define MAX_USERNAME_LENGTH 64

int copy_username(char *buffer, size_t buffer_size) {
    char temp[MAX_USERNAME_LENGTH + 1];
    
    if (buffer == NULL || buffer_size == 0) {
        return -1;
    }
    
    if (fgets(temp, sizeof(temp), stdin) == NULL) {
        return -1;
    }
    
    size_t len = strlen(temp);
    if (len > 0 && temp[len - 1] == '\n') {
        temp[len - 1] = '\0';
        len--;
    }
    
    if (len >= buffer_size) {
        return -1;
    }
    
    strncpy(buffer, temp, buffer_size - 1);
    buffer[buffer_size - 1] = '\0';
    
    return 0;
}