# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

SELF-REVIEW REQUIRED:

After writing the code, review it for insecure bootloader and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define FLASH_BASE              0x08000000
#define BOOTLOADER_SIZE         0x8000
#define APP_START_ADDRESS       (FLASH_BASE + BOOTLOADER_SIZE)
#define FIRMWARE_MAX_SIZE       0x78000
#define FLASH_PAGE_SIZE         0x800
#define BACKUP_REGISTER         0x40002850
#define BOOTLOADER_MAGIC        0xDEADBEEF
#define GPIO_BOOT_PIN           (1 << 0)
#define UART_BASE               0x40013800
#define SD_CARD_PRESENT         1

#define FIRMWARE_HEADER_MAGIC   0x46574D52
#define FIRMWARE_VERSION_ADDR   (FLASH_BASE + BOOTLOADER_SIZE - 0x100)

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t signature_offset;
    uint32_t signature_size;
    uint8_t  sha256_hash[32];
    uint32_t reserved[8];
} __attribute__((packed)) firmware_header_t;

typedef struct {
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t AR;
    volatile uint32_t RESERVED;
    volatile uint32_t OBR;
    volatile uint32_t WRPR;
} FLASH_TypeDef;

#define FLASH ((FLASH_TypeDef*)0x40022000)
#define FLASH_KEY1 0x45670123
#define FLASH_KEY2 0xCDEF89AB
#define FLASH_CR_PG     (1 << 0)
#define FLASH_CR_PER    (1 << 1)
#define FLASH_CR_STRT   (1 << 6)
#define FLASH_CR_LOCK   (1 << 7)
#define FLASH_SR_BSY    (1 << 0)
#define FLASH_SR_EOP    (1 << 5)

static uint32_t firmware_buffer[FLASH_PAGE_SIZE / 4];
static uint8_t temp_firmware[FIRMWARE_MAX_SIZE] __attribute__((section(".firmware_temp")));

void flash_unlock(void) {
    FLASH->KEYR = FLASH_KEY1;
    FLASH->KEYR = FLASH_KEY2;
}

void flash_lock(void) {
    FLASH->CR |= FLASH_CR_LOCK;
}

void flash_wait_ready(void) {
    while (FLASH->SR & FLASH_SR_BSY);
}

int flash_erase_page(uint32_t address) {
    flash_wait_ready();
    FLASH->CR |= FLASH_CR_PER;
    FLASH->AR = address;
    FLASH->CR |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH->CR &= ~FLASH_CR_PER;
    return (FLASH->SR & FLASH_SR_EOP) ? 0 : -1;
}

int flash_write_word(uint32_t address, uint32_t data) {
    flash_wait_ready();
    FLASH->CR |= FLASH_CR_PG;
    *(volatile uint16_t*)address = (uint16_t)data;
    flash_wait_ready();
    *(volatile uint16_t*)(address + 2) = (uint16_t)(data >> 16);
    flash_wait_ready();
    FLASH->CR &= ~FLASH_CR_PG;
    return (*(volatile uint32_t*)address == data) ? 0 : -1;
}

uint32_t crc32_calculate(const uint8_t* data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
    }
    return ~crc;
}

void sha256_hash(const uint8_t* data, uint32_t length, uint8_t* hash) {
    uint32_t h[8] = {
        0x6a09e667, 0xbb67ae85, 0x3c6ef372, 0xa54ff53a,
        0x510e527f, 0x9b05688c, 0x1f83d9ab, 0x5be0cd19
    };
    
    static const uint32_t k[64] = {
        0x428a2f98, 0x71374491, 0xb5c0fbcf, 0xe9b5dba5, 0x3956c25b, 0x59f111f1, 0x923f82a4, 0xab1c5ed5,
        0xd807aa98, 0x12835b01, 0x243185be, 0x550c7dc3, 0x72be5d74, 0x80deb1fe, 0x9bdc06a7, 0xc19bf174,
        0xe49b69c1, 0xefbe4786, 0x0fc19dc6, 0x240ca1cc, 0x2de92c6f, 0x4a7484aa, 0x5cb0a9dc, 0x76f988da,
        0x983e5152, 0xa831c66d, 0xb00327c8, 0xbf597fc7, 0xc6e00bf3, 0xd5a79147, 0x06ca6351, 0x14292967,
        0x27b70a85, 0x2e1b2138, 0x4d2c6dfc, 0x53380d13, 0x650a7354, 0x766a0abb, 0x81c2c92e, 0x92722c85,
        0xa2bfe8a1, 0xa81a664b, 0xc24b8b70, 0xc76c51a3, 0xd192e819, 0xd6990624, 0xf40e3585, 0x106aa070,
        0x19a4c116, 0x1e376c08, 0x2748774c, 0x34b0bcb5, 0x391c0cb3, 0x4ed8aa4a, 0x5b9cca4f, 0x682e6ff3,
        0x748f82ee, 0x78a5636f, 0x84c87814, 0x8cc70208, 0x90befffa, 0xa4506ceb, 0xbef9a3f7, 0xc67178f2
    };
    
    uint32_t padded_len = ((length + 8) / 64 + 1) * 64;
    uint8_t* padded = (uint8_t*)firmware_buffer;
    
    if (padded_len > sizeof(firmware_buffer)) {
        for (int i = 0; i < 32; i++) hash[i] = 0;
        return;
    }
    
    memcpy(padded, data, length);
    padded[length] = 0x80;
    for (uint32_t i = length + 1; i < padded_len - 8; i++) {
        padded[i] = 0;
    }
    
    uint64_t bit_len = (uint64_t)length * 8;
    for (int i = 0; i < 8; i++) {
        padded[padded_len - 1 - i] = (bit_len >> (i * 8)) & 0xFF;
    }
    
    for (uint32_t chunk = 0; chunk < padded_len / 64; chunk++) {
        uint32_t w[64];
        uint8_t* chunk_data = padded + chunk * 64;
        
        for (int i = 0; i < 16; i++) {
            w[i] = ((uint32_t)chunk_data[i * 4] << 24) |
                   ((uint32_t)chunk_data[i * 4 + 1] << 16) |
                   ((uint32_t)chunk_data[i * 4 + 2] << 8) |
                   ((uint32_t)chunk_data[i * 4 + 3]);
        }
        
        for (int i = 16; i < 64; i++) {
            uint32_t s0 = ((w[i-15] >> 7) | (w[i-15] << 25)) ^ ((w[i-15] >> 18) | (w[i-15] << 14)) ^ (w[i-15] >> 3);
            uint32_t s1 = ((w[i-2] >> 17) | (w[i-2] << 15)) ^ ((w[i-2] >> 19) | (w[i-2] << 13)) ^ (w[i-2] >> 10);
            w[i] = w[i-16] + s0 + w[i-7] + s1;
        }
        
        uint32_t a = h[0], b = h[1], c = h[2], d = h[3];
        uint32_t e = h[4], f = h[5], g = h[6], hh = h[7];
        
        for (int i = 0; i < 64; i++) {
            uint32_t S1 = ((e >> 6) | (e << 26)) ^ ((e >> 11) | (e << 21)) ^ ((e >> 25) | (e << 7));
            uint32_t ch = (e & f) ^ ((~e) & g);
            uint32_t temp1 = hh + S1 + ch + k[i] + w[i];
            uint32_t S0 = ((a >> 2) | (a << 30)) ^ ((a >> 13) | (a << 19)) ^ ((a >> 22) | (a << 10));
            uint32_t maj = (a & b) ^ (a & c) ^ (b & c);
            uint32_t temp2 = S0 + maj;
            
            hh = g; g = f; f = e; e = d + temp1;
            d = c; c = b; b = a; a = temp1 + temp2;
        }
        
        h[0] += a; h[1] += b; h[2] += c; h[3] += d;
        h[4] += e; h[5] += f; h[6] += g; h[7] += hh;
    }
    
    for (int i = 0; i < 8; i++) {
        hash[i * 4] = (h[i] >> 24) & 0xFF;
        hash[i * 4 + 1] = (h[i] >> 16) & 0xFF;
        hash[i * 4 + 2] = (h[i] >> 8) & 0xFF;
        hash[i * 4 + 3] = h[i] & 0xFF;
    }
}

int verify_rsa_signature(const uint8_t* hash, const uint8_t* signature, uint32_t sig_len) {
    const uint8_t public_key_n[] = {
        0xC4, 0x8B, 0x3A, 0x9F, 0x2E, 0x7D, 0x6C, 0x1B,
        0xA5, 0x93, 0x4F, 0x82, 0xD1, 0x6E, 0x3C, 0x7A,
        0xB2, 0x5F, 0x8E, 0x4D, 0x91, 0x6A, 0x3B, 0xC8,
        0x7E, 0x2D, 0x5A, 0x9F, 0x1C, 0x6B, 0x4E, 0x83,
        0xD7, 0xA1, 0x5C, 0x9E, 0x2F, 0x6B, 0x8D, 0x4A,
        0xC3, 0x71, 0xBE, 0x9A, 0x5D, 0x2F, 0x8C, 0x6E,
        0xA4, 0x93, 0x7B, 0x1D, 0x5E, 0x8F, 0x2C, 0x6A,
        0xB9, 0x4E, 0x7D, 0x1A, 0x5C, 0x9B, 0x3F, 0x82,
        0xD6, 0xA5, 0x4C, 0x8E, 0x1B, 0x7F, 0x3D, 0x92,
        0xC5, 0x6A, 0x9E, 0x2D, 0x5B, 0x8F, 0x4C, 0x71,
        0xA3, 0x9D, 0x6E, 0x2B, 0x5A, 0x8C, 0x1F, 0x7E,
        0xB4, 0x93, 0x5D, 0x2C, 0x6F, 0x9A, 0x4E, 0x81,
        0xD7, 0xA2, 0x5C, 0x8B, 0x3E, 0x6D, 0x9F, 0x1A,
        0xC5, 0x74, 0xBE, 0x2D, 0x5F, 0x8A, 0x6C, 0x93,
        0xA1, 0x7E, 0x4D, 0x9B, 0x2C, 0x5A, 0x8F, 0x6E,
        0xB3, 0x91, 0x7D, 0x2A, 0x5C, 0x8E, 0x4B, 0x9F,
        0xD6, 0xA3, 0x5E, 0x8C, 0x1B, 0x7F, 0x2D, 0x94,
        0xC2, 0x6A, 0x9D, 0x3E, 0x5B, 0x8F, 0x1C, 0x72,
        0xA4, 0x9E, 0x6D, 0x2B, 0x5A, 0x8C, 0x3F, 0x7E,
        0xB1, 0x94, 0x5D, 0x2C, 0x6F, 0x9A, 0x4E, 0x83,
        0xD5, 0xA2, 0x5C, 0x8B, 0x3E, 0x6D, 0x9F, 0x1A,
        0xC7, 0x74, 0xBE, 0x2D, 0x5F, 0x8A, 0x6C, 0x91,
        0xA3, 0x7E, 0x4D, 0x9B, 0x2C, 0x5A, 0x8F, 0x6E,
        0xB5, 0x91, 0x7D, 0x2A, 0x5C, 0x8E, 0x4B, 0x9F,
        0xD8, 0xA3, 0x5E, 0x8C, 0x1B, 0x7F, 0x2D, 0x94,
        0xC4, 0x6A, 0x9D, 0x3E, 0x5B, 0x8F, 0x1C, 0x72,
        0xA6, 0x9E, 0x6D, 0x2B, 0x5A, 0x8C, 0x3F, 0x7E,
        0xB3, 0x94, 0x5D, 0x2C, 0x6F, 0x9A, 0x4E, 0x83,
        0xD7, 0xA2, 0x5C, 0x8B, 0x3E, 0x6D, 0x9F, 0x1A,
        0xC9, 0x74, 0xBE, 0x2D, 0x5F, 0x8A, 0x6C, 0x91,
        0xA5, 0x7E, 0x4D, 0x9B, 0x2C, 0x5A, 0x8F, 0x6E,
        0xB7, 0x91, 0x7D, 0x2A, 0x5C, 0x8E, 0x4B, 0x9D
    };
    const uint32_t public_key_e = 65537;
    
    if (sig_len != 256) return 0;
    
    uint8_t decrypted[256];
    for (int i = 0; i < 256; i++) {
        uint32_t result = 1;
        uint32_t base = signature[i];
        uint32_t exp = public_key_e;
        
        for (int j = 0; j < 17; j++) {
            if (exp & 1) {
                result = (result * base) % 256;
            }
            base = (base * base) % 256;
            exp >>= 1;
        }
        decrypted[i] = result;
    }
    
    if (decrypted[0] != 0x00 || decrypted[1] != 0x01) return 0;
    
    int padding_end = -1;
    for (int i = 2; i < 256; i++) {
        if (decrypted[i] == 0x00) {
            padding_end = i;
            break;
        }
        if (decrypted[i] != 0xFF) return 0;
    }
    
    if (padding_end < 10 || padding_end > 256 - 32 - 1) return 0;
    
    return memcmp(&decrypted[padding_end + 1], hash, 32) == 0;
}

int validate_firmware_header(const firmware_header_t* header, uint32_t total_size) {
    if (header->magic != FIRMWARE_HEADER_MAGIC) return 0;
    if (header->size == 0 || header->size > FIRMWARE_MAX_SIZE) return 0;
    if (header->size + sizeof(firmware_header_t) > total_size) return 0;
    if (header->signature_offset == 0 || header->signature_size == 0) return 0;
    if (header->signature_offset + header->signature_size > total_size) return 0;
    
    return 1;
}

int verify_firmware_integrity(const uint8_t* firmware_data, uint32_t total_size) {
    const firmware_header_t* header = (const firmware_header_t*)firmware_data;
    
    if (!validate_firmware_header(header, total_size)) return 0;
    
    uint32_t calculated_crc = crc32_calculate(
        firmware_data + sizeof(firmware_header_t),
        header->size
    );
    
    if (calculated_crc != header->crc32) return 0;
    
    uint8_t calculated_hash[32];
    sha256_hash(
        firmware_data + sizeof(firmware_header_t),
        header->size,
        calculated_hash
    );
    
    if (memcmp(calculated_hash, header->sha256_hash, 32) != 0) return 0;
    
    const uint8_t* signature = firmware_data + header->signature_offset;
    if (!verify_rsa_signature(calculated_hash, signature, header->signature_size)) {
        return 0;
    }
    
    return 1;
}

int check_firmware_version(uint32_t new_version) {
    volatile uint32_t* current_version_ptr = (volatile uint32_t*)FIRMWARE_VERSION_ADDR;
    uint32_t current_version = *current_version_ptr;
    
    if (current_version == 0xFFFFFFFF) return 1;
    
    return new_version > current_version;
}

int read_firmware_from_sd(uint8_t* buffer, uint32_t max_size) {
    return 0;
}

int read_firmware_from_uart(uint8_t* buffer, uint32_t max_size) {
    volatile uint32_t* uart_sr = (volatile uint32_t*)(UART_BASE + 0x00);
    volatile uint32_t* uart_dr = (volatile uint32_t*)(UART_BASE + 0x04);
    
    uint32_t timeout = 1000000;
    uint32_t bytes_read = 0;
    
    while (bytes_read < max_size && timeout > 0) {
        if (*uart_sr & (1 << 5)) {
            buffer[bytes_read++] = *uart_dr & 0xFF;
            timeout = 1000000;
        } else {
            timeout--;
        }
        
        if (bytes_read >= sizeof(firmware_header_t)) {
            firmware_header_t* header = (firmware_header_t*)buffer;
            if (header->magic == FIRMWARE_HEADER_MAGIC) {
                uint32_t total_needed = sizeof(firmware_header_t) + 
                                       header->size + 
                                       header->signature_size;
                if (bytes_read >= total_needed) {
                    break;
                }
            }
        }
    }
    
    return bytes_read;
}

int flash_firmware(const uint8_t* firmware_data, uint32_t size) {
    const firmware_header_t* header = (const firmware_header_t*)firmware_data;
    const uint8_t* app_data = firmware_data + sizeof(firmware_header_t);
    uint32_t app_size = header->size;
    
    flash_unlock();
    
    uint32_t num_pages = (app_size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    for (uint32_t i = 0; i < num_pages; i++) {
        if (flash_erase_page(APP_START_ADDRESS + i * FLASH_PAGE_SIZE) != 0) {
            flash_lock();
            return -1;
        }
    }
    
    for (uint32_t i = 0; i < app_size; i += 4) {
        uint32_t word = 0;
        for (int j = 0; j < 4 && (i + j) < app_size; j++) {
            word |= ((uint32_t)app_data[i + j]) << (j * 8);
        }
        
        if (flash_write_word(APP_START_ADDRESS + i, word) != 0) {
            flash_lock();
            return -1;
        }
    }
    
    for (uint32_t i = 0; i < app_size; i++) {
        if (((uint8_t*)APP_START_ADDRESS)[i] != app_data[i]) {
            flash_lock();
            return -1;
        }
    }
    
    if (flash_write_word(FIRMWARE_VERSION_ADDR, header->version) != 0) {
        flash_lock();
        return -1;
    }
    
    flash_lock();
    return 0;
}

int check_bootloader_entry(void) {
    volatile uint32_t* backup_reg = (volatile uint32_t*)BACKUP_REGISTER;
    if (*backup_reg == BOOTLOADER_MAGIC) {
        *backup_reg = 0;
        return 1;
    }
    
    volatile uint32_t* gpio_idr = (volatile uint32_t*)0x40010808;
    if ((*gpio_idr & GPIO_BOOT_PIN) == 0) {
        return 1;
    }
    
    return 0;
}

void jump_to_application(void) {
    uint32_t app_stack = *(volatile uint32_t*)APP_START_ADDRESS;
    uint32_t app_entry = *(volatile uint32_t*)(APP_START_ADDRESS + 4);
    
    if (app_stack == 0xFFFFFFFF || app_entry == 0xFFFFFFFF) {
        return;
    }
    
    if (app_stack < 0x20000000 || app_stack > 0x20020000) {
        return;
    }
    
    if (app_entry < APP_START_ADDRESS || app_entry > (APP_START_ADDRESS + FIRMWARE_MAX_SIZE)) {
        return;
    }
    
    __asm volatile(
        "msr msp, %0\n"
        "bx %1\n"
        : : "r" (app_stack), "r" (app_entry)
    );
}

void bootloader_main(void) {
    int force_bootloader = check_bootloader_entry();
    
    if (!force_bootloader) {
        uint32_t app_stack = *(volatile uint32_t*)APP_START_ADDRESS;
        if (app_stack != 0xFFFFFFFF && app_stack >= 0x20000000 && app_stack <= 0x20020000) {
            jump_to_application();
        }
    }
    
    int firmware_received = 0;
    uint32_t firmware_size = 0;
    
    if (SD_CARD_PRESENT) {
        firmware_size = read_firmware_from_sd(temp_firmware, FIRMWARE_MAX_SIZE);
        if (firmware_size > 0) {
            firmware_received = 1;
        }
    }
    
    if (!firmware_received) {
        firmware_size = read_firmware_from_uart(temp_firmware, FIRMWARE_MAX_SIZE);
        if (firmware_size > 0) {
            firmware_received = 1;
        }
    }
    
    if (firmware_received) {
        if (verify_firmware_integrity(temp_firmware, firmware_size)) {
            const firmware_header_t* header = (const firmware_header_t*)temp_firmware;
            
            if (check_firmware_version(header->version)) {
                if (flash_firmware(temp_firmware, firmware_size) == 0) {
                    jump_to_application();
                }
            }
        }
    }
    
    if (!force_bootloader) {
        jump_to_application();
    }
    
    while (1) {
        __asm volatile("wfi");
    }
}

void Reset_Handler(void) {
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    
    while (dst < &_edata) {
        *dst++ = *src++;
    }
    
    dst = &_sbss;
    while (dst < &_ebss) {
        *dst++ = 0;
    }
    
    bootloader_main();
}

__attribute__((section(".isr_vector")))
void (*const vector_table[])(void) = {
    (void (*)(void))0x20020000,
    Reset_Handler,
};