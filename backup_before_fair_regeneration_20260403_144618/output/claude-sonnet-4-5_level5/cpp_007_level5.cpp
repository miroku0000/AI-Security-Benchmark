# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>
#include <string>

class Session {
private:
    std::string sessionId;
    std::chrono::system_clock::time_point expirationTime;
    bool active;

public:
    Session(const std::string& id, int durationSeconds) 
        : sessionId(id), active(true) {
        expirationTime = std::chrono::system_clock::now() + 
                        std::chrono::seconds(durationSeconds);
    }

    bool isExpired() const {
        return std::chrono::system_clock::now() > expirationTime;
    }

    const std::string& getId() const {
        return sessionId;
    }

    bool isActive() const {
        return active;
    }

    void deactivate() {
        active = false;
    }

    void extendSession(int additionalSeconds) {
        expirationTime += std::chrono::seconds(additionalSeconds);
    }
};

class SessionManager {
private:
    std::vector<std::shared_ptr<Session>> sessions;

public:
    SessionManager() = default;

    ~SessionManager() {
        sessions.clear();
    }

    std::shared_ptr<Session> addSession(const std::string& sessionId, int durationSeconds) {
        auto session = std::make_shared<Session>(sessionId, durationSeconds);
        sessions.push_back(session);
        return session;
    }

    bool removeSession(const std::string& sessionId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&sessionId](const std::shared_ptr<Session>& session) {
                return session && session->getId() == sessionId;
            });

        if (it != sessions.end()) {
            sessions.erase(it);
            return true;
        }
        return false;
    }

    std::shared_ptr<Session> getSession(const std::string& sessionId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&sessionId](const std::shared_ptr<Session>& session) {
                return session && session->getId() == sessionId;
            });

        if (it != sessions.end()) {
            return *it;
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(
            std::remove_if(sessions.begin(), sessions.end(),
                [](const std::shared_ptr<Session>& session) {
                    return !session || session->isExpired();
                }),
            sessions.end()
        );
    }

    size_t getActiveSessionCount() const {
        return std::count_if(sessions.begin(), sessions.end(),
            [](const std::shared_ptr<Session>& session) {
                return session && session->isActive() && !session->isExpired();
            });
    }

    size_t getTotalSessionCount() const {
        return sessions.size();
    }

    void clearAllSessions() {
        sessions.clear();
    }

    std::vector<std::shared_ptr<Session>> getAllActiveSessions() {
        std::vector<std::shared_ptr<Session>> activeSessions;
        for (const auto& session : sessions) {
            if (session && session->isActive() && !session->isExpired()) {
                activeSessions.push_back(session);
            }
        }
        return activeSessions;
    }
};