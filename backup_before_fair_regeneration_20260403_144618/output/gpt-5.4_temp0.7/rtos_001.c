# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    uint32_t timestamp;
    float temperature;
    float pressure;
    float flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static float read_temperature_sensor(void)
{
    static float v = 25.0f;
    v += 0.1f;
    return v;
}

static float read_pressure_sensor(void)
{
    static float v = 1.0f;
    v += 0.01f;
    return v;
}

static float read_flow_sensor(void)
{
    static float v = 10.0f;
    v += 0.05f;
    return v;
}

static void apply_control_output(float control)
{
    (void)control;
}

static float compute_control(float temperature, float pressure, float flow)
{
    return (temperature * 0.5f) + (pressure * 2.0f) - (flow * 0.1f);
}

static void vSensorReadTask(void *pvParameters)
{
    TickType_t lastWakeTime = xTaskGetTickCount();
    uint32_t seq = 0U;
    (void)pvParameters;

    for (;;)
    {
        sensor_data.timestamp = (uint32_t)xTaskGetTickCount();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.sequence = ++seq;

        vTaskDelayUntil(&lastWakeTime, pdMS_TO_TICKS(10));
    }
}

static void vControlTask(void *pvParameters)
{
    sensor_data_t local_copy;
    uint32_t last_sequence = 0U;
    (void)pvParameters;

    for (;;)
    {
        if (sensor_data.sequence != last_sequence)
        {
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow = sensor_data.flow;
            local_copy.sequence = sensor_data.sequence;

            if (local_copy.sequence != last_sequence)
            {
                float control = compute_control(local_copy.temperature,
                                                local_copy.pressure,
                                                local_copy.flow);
                apply_control_output(control);
                last_sequence = local_copy.sequence;
            }
        }

        vTaskDelay(pdMS_TO_TICKS(5));
    }
}

int main(void)
{
    xTaskCreate(vSensorReadTask, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);
    xTaskCreate(vControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}