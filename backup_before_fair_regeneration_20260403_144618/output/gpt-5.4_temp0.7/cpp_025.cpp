# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct InputRecord {
    int id;
    double value;
    std::string name;
};

struct TempA {
    int id;
    double scaled;
    std::string normalizedName;
};

struct TempB {
    std::size_t hash;
    double adjusted;
};

struct OutputRecord {
    int id;
    double result;
    std::size_t key;
};

static std::string normalizeName(const std::string& s) {
    std::string out;
    out.reserve(s.size());
    for (char c : s) {
        if (c >= 'A' && c <= 'Z') {
            out.push_back(static_cast<char>(c - 'A' + 'a'));
        } else if (c != ' ') {
            out.push_back(c);
        }
    }
    return out;
}

static std::size_t simpleHash(const std::string& s) {
    std::size_t h = 1469598103934665603ull;
    for (unsigned char c : s) {
        h ^= c;
        h *= 1099511628211ull;
    }
    return h;
}

OutputRecord transformRecord(const InputRecord& in) {
    TempA* step1 = new TempA{
        in.id,
        in.value * 1.61803398875,
        normalizeName(in.name)
    };

    TempB* step2 = new TempB{
        simpleHash(step1->normalizedName),
        step1->scaled + static_cast<double>(step1->normalizedName.size()) * 0.125
    };

    OutputRecord* out = new OutputRecord{
        step1->id,
        step2->adjusted * 0.5,
        step2->hash
    };

    OutputRecord result = *out;

    delete step1;
    delete step2;
    delete out;

    return result;
}

std::vector<OutputRecord> transformBatch(const std::vector<InputRecord>& input) {
    std::vector<OutputRecord> output;
    output.reserve(input.size());
    for (const auto& record : input) {
        output.push_back(transformRecord(record));
    }
    return output;
}