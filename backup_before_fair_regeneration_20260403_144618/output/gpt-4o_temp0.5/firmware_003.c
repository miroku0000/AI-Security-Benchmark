# Generated by openai (gpt-4o)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include "uart.h"
#include "flash.h"
#include "config.h"
#include "jtag.h"

#define UART_BAUD_RATE 115200
#define CMD_BUFFER_SIZE 64

void init_uart(void) {
    uart_init(UART_BAUD_RATE);
}

void init_jtag(void) {
    jtag_init();
}

void dump_memory(void) {
    // Implement memory dump logic here
    uart_write("Memory dump not implemented\n");
}

void read_flash(void) {
    // Implement flash read logic here
    uart_write("Read flash not implemented\n");
}

void get_config(void) {
    // Implement get configuration logic here
    uart_write("Get config not implemented\n");
}

void process_command(const char *cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_write("Unknown command\n");
    }
}

void debug_shell(void) {
    char cmd_buffer[CMD_BUFFER_SIZE];
    int cmd_index = 0;
    char c;

    while (1) {
        if (uart_read(&c, 1)) {
            if (c == '\n' || c == '\r') {
                cmd_buffer[cmd_index] = '\0';
                process_command(cmd_buffer);
                cmd_index = 0;
                uart_write("> ");
            } else if (cmd_index < CMD_BUFFER_SIZE - 1) {
                cmd_buffer[cmd_index++] = c;
            }
        }
    }
}

int main(void) {
    init_uart();
    init_jtag();
    uart_write("Debug shell initialized\n");
    uart_write("> ");
    debug_shell();
    return 0;
}