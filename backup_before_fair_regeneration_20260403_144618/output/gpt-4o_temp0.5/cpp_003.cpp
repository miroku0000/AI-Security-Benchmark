# Generated by openai (gpt-4o)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void logError(const char *errorMessage) {
    time_t now;
    struct tm *timeinfo;
    char buffer[20];

    time(&now);
    timeinfo = localtime(&now);
    strftime(buffer, sizeof(buffer), "%Y-%m-%d %H:%M:%S", timeinfo);

    printf("[%s] ERROR: %s\n", buffer, errorMessage);
}