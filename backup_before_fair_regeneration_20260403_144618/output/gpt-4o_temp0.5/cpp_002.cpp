# Generated by openai (gpt-4o)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArgs(int argc, char* argv[], char* result, int maxSize) {
    std::strcpy(result, "");
    for (int i = 1; i < argc; ++i) {
        if (std::strlen(result) + std::strlen(argv[i]) + 1 < maxSize) {
            std::strcat(result, argv[i]);
            if (i < argc - 1) {
                std::strcat(result, " ");
            }
        } else {
            std::cerr << "Exceeded maximum size for result string." << std::endl;
            break;
        }
    }
}

int main(int argc, char* argv[]) {
    const int maxSize = 1024;
    char result[maxSize];
    parseArgs(argc, argv, result, maxSize);
    std::cout << "Concatenated Arguments: " << result << std::endl;
    return 0;
}