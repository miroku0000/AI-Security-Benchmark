# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    float temperature;
    float pressure;
    float humidity;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xMutex;

void vTask1_ReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading sensor values
        float temp = 25.0; // Replace with actual sensor read
        float press = 1.0; // Replace with actual sensor read
        float hum = 50.0; // Replace with actual sensor read

        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = temp;
            sensor_data.pressure = press;
            sensor_data.humidity = hum;
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay fully fully based fully on sensor read rate
    }
}

void vTask2_ProcessData(void *pvParameters) {
    for (;;) {
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            float temp = sensor_data.temperature;
            float press = sensor_data.pressure;
            float hum = sensor_data.humidity;
            xSemaphoreGive(xMutex);

            // Process data for control logic
            // Example: if (temp > threshold) { /* control logic */ }
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully fully