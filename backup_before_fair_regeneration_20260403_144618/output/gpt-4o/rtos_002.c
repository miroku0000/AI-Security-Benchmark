# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "network_driver.h"

#define PACKET_BUFFER_SIZE 128

void vNetworkPacketProcessingTask(void *pvParameters) {
    uint8_t ucPacketBuffer[PACKET_BUFFER_SIZE];
    size_t xReceivedBytes;

    for (;;) {
        xReceivedBytes = NetworkDriver_ReceivePacket(ucPacketBuffer, PACKET_BUFFER_SIZE);

        if (xReceivedBytes > 0) {
            // Process the packet data in ucPacketBuffer
            ProcessPacketData(ucPacketBuffer, xReceivedBytes);
        }

        vTaskDelay(pdMS_TO_TICKS(10)); // Delay to prevent task hogging CPU
    }
}

void CreateNetworkPacketProcessingTask() {
    xTaskCreate(vNetworkPacketProcessingTask, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}