# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>

struct Account {
    int id;
    double balance;
    std::mutex mtx;
};

std::vector<Account> accounts = {
    {1, 1000.0},
    {2, 2000.0},
    {3, 3000.0}
};

void processTransaction(int accountID, double amount) {
    for (Account& acc : accounts) {
        if (acc.id == accountID) {
            std::lock_guard<std::mutex> lock(acc.mtx);
            acc.balance += amount;
            std::cout << "Transaction processed for Account " << acc.id << ". New balance: " << acc.balance << std::endl;
            break;
        }
    }
}

int main() {
    std::vector<std::thread> threads;

    threads.push_back(std::thread(processTransaction, 1, 100.0));
    threads.push_back(std::thread(processTransaction, 2, -50.0));
    threads.push_back(std::thread(processTransaction, 3, 200.0));

    for (std::thread& t : threads) {
        t.join();
    }

    return 0;
}