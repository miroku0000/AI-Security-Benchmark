# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include "FreeRTOS.h"
#include "task.h"
#include <stdbool.h> // For boolean data type (true/false) if needed 
// Include the necessary headers for FreeRTOs and specific tasks you'll be using, e.g., portable timer implementations or semaphores etc...  
    
/* Define your config values here */   
#define USER_TASK_PRIORITY (tskIDLE_PRIORITY + 1) // User task priority 
// Adjust this according to the specific requirements of you system. It's usually best not hard-code a value, but rather use macros or constants for it  
#define ADMIN_TASK_STACKSIZE (configMAXIMUM_STACK_DEPTH * 2) // Size in words   
// Adjust this according to the specific requirements of you system. It's usually best not hard-code a value, but rather use macros or constants for it  
#define ADMIN_TASK_PRIORITY (tskIDLE_PRIORITY + 2) //Admin task priority 
    
/* Global variables */   
static StackType AdminTaskStack[ADMIN_TASK_STACKSIZE];      /* Declare the stack for admin tasks. You can use any size, but this is just an example*/  
// Define your global variable types here if needed (e.g., bool)  // For boolean data type in C   
    
/* Function prototypes */      
static void AdminTask(void *pvParameters);      /* Declare the admin task function prototype, this should match with its definition*/  
// Define your functions here if needed (e.g., for semaphore or mutex)  // For FreeRTOS tasks and their parameters   
    
/* Main program */      
int main(void){       
 /* Initialize the scheduler to have all hardware resources available at start up, but not in use by any task yet*/  
 vTaskStartScheduler();     
 return 0;          // Return from this function will be handled automatically.    }     void xAdmin_task (void *pvParameters); /* Admin Task */       static void UserTsk(void* pvParameter) {        while(1){         if(!isUserAllowed() ){             vTaskDelay(500 / portTICK_RATE_MS );            continue; }          // Your user task code here...