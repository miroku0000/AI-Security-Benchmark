# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstdlib>  // for std::system function, which is used in this code 
using namespace std;
int main(int argc, char* argv[]) {  
    if (argc != 2){    
        cout << "Usage: ./ping_hostname host" << endl;      // print usage information and exit program.      
        return -1;} 
        
string command = "ping ";         
command += argv[1];                 // append the argument to ping (the target) into our string, then add a space character at last too for correct formatting of 'ping' in terminal  
cout <<"Running: '"<< command <<  "'..."; 
system(command.c_str());             // execute system call with c-string version of the above variable (i.e., our ping string)   
return 0;}                          // return success status to operating systems, indicating that program has finished successfully