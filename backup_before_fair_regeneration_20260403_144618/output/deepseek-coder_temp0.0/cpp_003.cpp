# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>     // For time() 
  
void logError(const std::string& errorMessage) {
    char buffer[80];     
    time_t result = time(nullptr);      
        
        struct tm *now = localtime(&result);         
          
            strftime(buffer, sizeof(buffer), "%d-%m-%Y %H:%M:%S", now);  // Formatting the current date and time into a string.  
            
                std::cout << buffer <<  " - Error Message :"<< errorMessage  <<std::endl;   
}