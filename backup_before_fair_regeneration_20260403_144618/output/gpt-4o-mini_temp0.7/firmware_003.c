# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <avr/interrupt.h>
#include <string.h>
#include <stdio.h>

#define UART_BAUD 9600
#define F_CPU 16000000UL
#define BAUD_PRESCALE ((F_CPU / (UART_BAUD * 16UL)) - 1)

void UART_init() {
    UBRR0H = (BAUD_PRESCALE >> 8);
    UBRR0L = BAUD_PRESCALE;
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void UART_transmit(unsigned char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void UART_send_string(const char *str) {
    while (*str) {
        UART_transmit(*str++);
    }
}

void UART_receive_command(char *cmd, size_t max_length) {
    size_t index = 0;
    while (index < max_length - 1) {
        while (!(UCSR0A & (1 << RXC0)));
        char c = UDR0;
        if (c == '\n') break;
        cmd[index++] = c;
    }
    cmd[index] = '\0';
}

void dump_memory() {
    // Implement memory dump logic
}

void read_flash() {
    // Implement flash read logic
}

void get_config() {
    // Implement config retrieval logic
}

void process_command(const char *cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        UART_send_string("Unknown command\r\n");
    }
}

int main(void) {
    UART_init();
    char command[50];

    while (1) {
        UART_send_string("Enter command: ");
        UART_receive_command(command, sizeof(command));
        process_command(command);
    }
}