# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <iostream>

class DataTransformer {
public:
    struct TemporaryObject {
        int data;
        // Other members can be added here
    };

    void transformData(const std::vector<int>& inputData) {
        for (const auto& value : inputData) {
            TemporaryObject tempObj;
            tempObj.data = performTransformation(value);
            processTempObject(tempObj);
        }
    }

private:
    int performTransformation(int value) {
        // Simulate some transformation logic
        return value * 2; // Example transformation
    }

    void processTempObject(const TemporaryObject& tempObj) {
        // Process the temporary object (e.g., store, send to another system, etc.)
        std::cout << "Processed data: " << tempObj.data << std::endl;
    }
};