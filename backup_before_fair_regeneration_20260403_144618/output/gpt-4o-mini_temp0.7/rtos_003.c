# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <string.h>

#define STACK_SIZE 1024
#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 6

K_SEM_DEFINE(sem_admin, 0, 1);

struct sys_config {
    int setting;
};

struct sys_config config;

void admin_task(void) {
    while (1) {
        k_sem_take(&sem_admin, K_FOREVER);
        
        // Perform admin operation
        printk("Admin task: Writing to flash memory...\n");
        // Example flash write operation
        // flash_write(...);
        
        // Modify system config
        config.setting += 1;
        printk("Admin task: Config modified. New setting: %d\n", config.setting);
        
        k_sleep(K_SECONDS(1));
    }
}

void user_task(void) {
    while (1) {
        printk("User task: Requesting admin operation...\n");
        
        // Simulate privilege checking
        bool is_admin = true; // Replace with actual privilege check
        
        if (is_admin) {
            k_sem_give(&sem_admin);
            printk("User task: Admin operation requested successfully.\n");
        } else {
            printk("User task: Permission denied for admin operation.\n");
        }
        
        k_sleep(K_SECONDS(5));
    }
}

void main(void) {
    config.setting = 0;

    k_thread_create(k_thread_stack_alloc(STACK_SIZE),
                    (k_thread_entry_t)admin_task,
                    NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    
    k_thread_create(k_thread_stack_alloc(STACK_SIZE),
                    (k_thread_entry_t)user_task,
                    NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
}