# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

// UART configuration structure
typedef struct {
    uint32_t baudrate;
    uint8_t data_bits;
    uint8_t stop_bits;
    uint8_t parity;
} uart_config_t;

// JTAG configuration structure
typedef struct {
    bool enable_jtag;
    uint32_t jtag_clock_divisor;
} jtag_config_t;

// UART instance structure
typedef struct {
    uart_config_t config;
    void (*init)(void);
    void (*putchar)(uint8_t c);
    void (*puts)(const char *str);
} uart_instance_t;

// JTAG instance structure
typedef struct {
    jtag_config_t config;
    void (*enable)(void);
    void (*disable)(void);
} jtag_instance_t;

// UART initialization function
static void uart_init(uart_instance_t *uart) {
    // Initialize UART hardware
    // ...
}

// UART putchar function
static void uart_putchar(uart_instance_t *uart, uint8_t c) {
    // Send character over UART
    // ...
}

// UART puts function
static void uart_puts(uart_instance_t *uart, const char *str) {
    while (*str != '\0') {
        uart_putchar(uart, (uint8_t)*str);
        str++;
    }
}

// JTAG initialization function
static void jtag_init(jtag_instance_t *jtag) {
    // Initialize JTAG hardware
    // ...
}

// JTAG enable function
static void jtag_enable(jtag_instance_t *jtag) {
    // Enable JTAG
    // ...
}

// JTAG disable function
static void jtag_disable(jtag_instance_t *jtag) {
    // Disable JTAG
    // ...
}

// UART instance for production IoT devices
uart_instance_t uart_prod = {
    .config = {
        .baudrate = 9600,
        .data_bits = 8,
        .stop_bits = 1,
        .parity = 0
    },
    .init = uart_init,
    .putchar = uart_putchar,
    .puts = uart_puts
};

// JTAG instance for remote diagnostics
jtag_instance_t jtag_diag = {
    .config = {
        .enable_jtag = true,
        .jtag_clock_divisor = 1000
    },
    .enable = jtag_enable,
    .disable = jtag_disable
};

// Function to handle UART commands
void uart_command_handler(uart_instance_t *uart, const char *cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        // Dump memory contents over UART
        // ...
    } else if (strcmp(cmd, "read_flash") == 0) {
        // Read flash contents over UART
        // ...
    } else if (strcmp(cmd, "get_config") == 0) {
        // Get device configuration over UART
        // ...
    }
}

// Main function to initialize diagnostic console and JTAG
int main(void) {
    uart_init(&uart_prod);
    jtag_init(&jtag_diag);

    while (1) {
        uint8_t c;
        if (uart_putchar(&uart_prod, '\n') == 0) {
            // Read character from UART
            c = uart_putchar(&uart_prod, getchar());
            if (c != EOF) {
                uart_command_handler(&uart_prod, (const char *)&c);
            }
        }

        jtag_enable(&jtag_diag);

        // Perform JTAG operations here

        jtag_disable(&jtag_diag);
    }

    return 0;
}