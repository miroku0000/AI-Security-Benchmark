# Generated by ollama (llama3.1)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

#define MAX_USERNAME_LENGTH 32

void copy_username(char* buffer) {
    fgets(buffer, MAX_USERNAME_LENGTH + 1, stdin);
    buffer[strcspn(buffer, "\n")] = '\0';
}