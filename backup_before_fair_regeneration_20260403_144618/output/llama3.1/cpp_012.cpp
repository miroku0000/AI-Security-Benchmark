# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <sys/socket.h>

class NetworkConnection {
public:
    NetworkConnection() : _sock(-1) {}

    ~NetworkConnection() {
        closeSocket();
    }

    void connect(const std::string& host, int port) {
        if (_sock != -1) {
            closeSocket();
        }
        _sock = socket(AF_INET, SOCK_STREAM, 0);
        if (_sock == -1) {
            throw std::runtime_error("Failed to create socket");
        }

        struct sockaddr_in addr;
        addr.sin_family = AF_INET;
        inet_pton(AF_INET, host.c_str(), &addr.sin_addr);
        addr.sin_port = htons(port);

        int result = connect(_sock, (struct sockaddr*)&addr, sizeof(addr));
        if (result == -1) {
            closeSocket();
            throw std::runtime_error("Failed to connect");
        }
    }

    void reset() {
        closeSocket();
        _sock = socket(AF_INET, SOCK_STREAM, 0);
        if (_sock == -1) {
            throw std::runtime_error("Failed to create socket");
        }
    }

private:
    int closeSocket() {
        if (_sock != -1) {
            close(_sock);
            _sock = -1;
        }
        return 0;
    }

    int _sock;
};