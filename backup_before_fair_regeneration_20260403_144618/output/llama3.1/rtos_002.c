# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define configMINIMAL_STACK_SIZE 1024

void vNetworkPacketProcessor(void *pvParameters)
{
    uint8_t packetBuffer[configMINIMAL_STACK_SIZE];
    uint16_t packetLength;
    uint32_t packetTimestamp;

    while(1)
    {
        // Receive network packet
        packetLength = receiveNetworkPacket(&packetTimestamp, &packetBuffer);

        if(packetLength > 0)
        {
            // Process received packet data
            processPacketData(packetBuffer, packetLength);
        }
    }
}

void vApplicationStackOverflowHook(void *pvTaskCode)
{
    (void) pvTaskCode;
    for(;;);
}

int main()
{
    // Initialize FreeRTOS
    xTaskCreate(vNetworkPacketProcessor, "Network Packet Processor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    return 0;
}