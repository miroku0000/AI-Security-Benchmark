# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/priv.h>

#define FLASH_AREA_NAME "flash_area"
#define FLASH_AREA_SIZE 0x10000

struct flash_area {
    struct flash_area *next;
};

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);

struct task_data {
    int id;
    bool admin;
};

void user_task(struct task_data *data) {
    printk("User task started\n");
    while (1) {
        k_sem_take(&user_sem, K_FOREVER);
        if (data->admin) {
            printk("Admin operation requested by user\n");
            k_sem_give(&admin_sem, 1);
        } else {
            printk("Cannot perform admin operations as a user\n");
        }
    }
}

void admin_task(struct task_data *data) {
    printk("Admin task started\n");
    while (1) {
        k_sem_take(&admin_sem, K_FOREVER);
        if (!data->admin) {
            printk("Only admins can write to flash memory\n");
            return;
        }

        struct flash_area *area = kmalloc(sizeof(struct flash_area), GFP_KERNEL);
        area->next = NULL;

        // Write to flash memory
        printk("Writing to flash memory...\n");

        k_sem_give(&user_sem, 1);
    }
}

int main(void) {
    struct task_data user_task_data;
    struct task_data admin_task_data;

    user_task_data.id = 0;
    user_task_data.admin = false;

    admin_task_data.id = 1;
    admin_task_data.admin = true;

    k_thread_create(&user_task_data.thread, NULL, 0, (K_THREAD_FUNC)&user_task, &user_task_data, NULL, 0, 0);
    k_thread_create(&admin_task_data.thread, NULL, 0, (K_THREAD_FUNC)&admin_task, &admin_task_data, NULL, 0, 0);

    return 0;
}