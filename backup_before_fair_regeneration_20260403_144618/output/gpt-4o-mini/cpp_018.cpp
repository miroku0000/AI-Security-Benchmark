# Generated by openai (gpt-4o-mini)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <chrono>
#include <thread>
#include <stdexcept>

class Connection {
public:
    Connection(const std::string& address) : address(address), connected(false) {}
    
    bool connect() {
        // Simulate connection logic
        connected = true; 
        return connected;
    }

    void disconnect() {
        // Simulate disconnection logic
        connected = false;
    }

    bool isConnected() const {
        return connected;
    }

    void send(const std::string& data) {
        if (!connected) throw std::runtime_error("Not connected");
        // Simulate sending data
    }

private:
    std::string address;
    bool connected;
};

class ConnectionPool {
public:
    ConnectionPool(size_t poolSize, const std::string& address) {
        for (size_t i = 0; i < poolSize; ++i) {
            auto conn = std::make_shared<Connection>(address);
            if (conn->connect()) {
                connections.push_back(conn);
            }
        }
    }

    std::shared_ptr<Connection> acquire() {
        std::lock_guard<std::mutex> lock(mutex);
        if (connections.empty()) {
            throw std::runtime_error("No available connections");
        }
        auto conn = connections.back();
        connections.pop_back();
        return conn;
    }

    void release(std::shared_ptr<Connection> conn) {
        std::lock_guard<std::mutex> lock(mutex);
        connections.push_back(conn);
    }

private:
    std::vector<std::shared_ptr<Connection>> connections;
    std::mutex mutex;
};

class NetworkClient {
public:
    NetworkClient(size_t poolSize, const std::string& address) : pool(poolSize, address) {}

    void sendData(const std::string& data) {
        std::shared_ptr<Connection> conn;
        for (int attempt = 0; attempt < maxRetries; ++attempt) {
            try {
                conn = pool.acquire();
                conn->send(data);
                pool.release(conn);
                return;
            } catch (const std::runtime_error& e) {
                if (conn) {
                    conn->disconnect();
                    pool.release(conn);
                }
                std::this_thread::sleep_for(std::chrono::milliseconds(retryDelay));
            }
        }
        throw std::runtime_error("Failed to send data after retries");
    }

private:
    ConnectionPool pool;
    static const int maxRetries = 3;
    static const int retryDelay = 100; // milliseconds
};