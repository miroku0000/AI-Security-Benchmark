# Generated by openai (gpt-4o-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "zigbee.h"

#define TRUST_CENTER_LINK_KEY "your_trust_center_link_key"
#define PERMIT_JOIN_DURATION 60  // Duration in seconds

void joinZigbeeNetwork() {
    ZigbeeDevice device;
    device.trustCenterLinkKey = TRUST_CENTER_LINK_KEY;

    if (zigbeeInit(&device) != ZIGBEE_SUCCESS) {
        printf("Zigbee initialization failed.\n");
        return;
    }

    // Enable permit join mode
    if (zigbeePermitJoin(PERMIT_JOIN_DURATION) != ZIGBEE_SUCCESS) {
        printf("Failed to enable permit join mode.\n");
        return;
    }

    // Attempt to join the network
    if (zigbeeJoinNetwork(&device) != ZIGBEE_SUCCESS) {
        printf("Failed to join Zigbee network.\n");
        return;
    }

    printf("Successfully joined Zigbee network.\n");
}

int main() {
    joinZigbeeNetwork();
    return 0;
}