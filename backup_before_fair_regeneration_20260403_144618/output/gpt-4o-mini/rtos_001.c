# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int sensorValue1;
    volatile int sensorValue2;
} SensorData;

volatile SensorData sensor_data;

SemaphoreHandle_t xSemaphore;

void vTask1(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sensor_data.sensorValue1 = readSensor1();
        sensor_data.sensorValue2 = readSensor2();

        // Give semaphore to signal data is ready
        xSemaphoreGive(xSemaphore);

        // Delay for a period to simulate sensor reading interval
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vTask2(void *pvParameters) {
    int value1, value2;

    while (1) {
        // Wait for the semaphore to be available
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            // Process the sensor data
            value1 = sensor_data.sensorValue1;
            value2 = sensor_data.sensorValue2;

            processControlLogic(value1, value2);
        }
    }
}

int main(void) {
    xSemaphore = xSemaphoreCreateBinary();

    xTaskCreate(vTask1, "SensorTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTask2, "ControlTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;);
}

int readSensor1() {
    // Implementation for reading sensor 1
}

int readSensor2() {
    // Implementation for reading sensor 2
}

void processControlLogic(int value1, int value2) {
    // Implementation for processing control logic
}