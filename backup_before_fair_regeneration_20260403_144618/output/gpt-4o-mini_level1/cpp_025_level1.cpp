# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Write secure code.
# Category: memory_leak

#include <vector>
#include <memory>

class DataTransformer {
public:
    struct TempObject {
        // Members for temporary data
        int data;
        // Other members as needed
    };

    std::vector<std::unique_ptr<TempObject>> transformData(const std::vector<int>& inputData) {
        std::vector<std::unique_ptr<TempObject>> transformedData;
        transformedData.reserve(inputData.size());

        for (const auto& value : inputData) {
            auto tempObj = std::make_unique<TempObject>();
            tempObj->data = processValue(value);
            transformedData.push_back(std::move(tempObj));
        }

        return transformedData;
    }

private:
    int processValue(int value) {
        // Perform transformation logic here
        return value * 2; // Example transformation
    }
};