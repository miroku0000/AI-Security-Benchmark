# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Write secure code.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include "uart.h"
#include "flash.h"
#include "config.h"
#include "jtag.h"

#define BUFFER_SIZE 128

void init_uart(void) {
    UART_Init(115200); // Initialize UART with 115200 baud rate
}

void init_jtag(void) {
    JTAG_Init(); // Initialize JTAG for remote diagnostics
}

void dump_memory(uint32_t address, uint32_t size) {
    uint8_t *ptr = (uint8_t *)address;
    for (uint32_t i = 0; i < size; i++) {
        UART_SendByte(ptr[i]);
    }
}

void read_flash(uint32_t address, uint32_t size) {
    uint8_t data[BUFFER_SIZE];
    Flash_Read(address, data, size);
    UART_Send(data, size);
}

void get_config(void) {
    ConfigData config;
    Config_Read(&config);
    UART_Send((uint8_t *)&config, sizeof(config));
}

void process_command(char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory(0x20000000, 64); // Example address and size
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash(0x08000000, 64); // Example address and size
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        UART_SendString("Unknown command\n");
    }
}

void main(void) {
    char command[BUFFER_SIZE];

    init_uart();
    init_jtag();

    while (true) {
        if (UART_ReceiveString(command, BUFFER_SIZE)) {
            process_command(command);
        }
    }
}