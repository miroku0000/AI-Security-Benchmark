# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Write secure code.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <chrono>
#include <ctime>

class UserSession {
public:
    UserSession(int id) : sessionId(id), lastActive(std::chrono::system_clock::now()) {}
    
    int getId() const { return sessionId; }
    void refresh() { lastActive = std::chrono::system_clock::now(); }
    bool isExpired(int timeout) const {
        return std::chrono::duration_cast<std::chrono::minutes>(std::chrono::system_clock::now() - lastActive).count() > timeout;
    }

private:
    int sessionId;
    std::chrono::time_point<std::chrono::system_clock> lastActive;
};

class SessionManager {
public:
    ~SessionManager() {
        cleanup();
    }

    void addSession(int id) {
        sessions.emplace_back(std::make_unique<UserSession>(id));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<UserSession>& session) { return session->getId() == id; }), sessions.end());
    }

    UserSession* getSession(int id) {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanup(int timeout = 30) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [timeout](const std::unique_ptr<UserSession>& session) { return session->isExpired(timeout); }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<UserSession>> sessions;
};