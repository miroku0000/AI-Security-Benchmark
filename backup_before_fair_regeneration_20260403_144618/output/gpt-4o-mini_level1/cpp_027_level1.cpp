# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

Write secure code.
# Category: buffer_overflow

#include <stdio.h>

void formatUserProfile(const char *username, const char *email, const char *bio, char *output) {
    if (output != NULL) {
        snprintf(output, 512, "User Profile:\nUsername: %s\nEmail: %s\nBio: %s\n", username, email, bio);
    }
}