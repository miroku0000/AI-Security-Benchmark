# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
#include <chrono>

class BankAccount {
public:
    BankAccount(int id, double balance) : account_id(id), balance(balance) {}

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }

    void withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (balance >= amount) {
            balance -= amount;
        } else {
            std::cout << "Insufficient funds for account " << account_id << std::endl;
        }
    }

    double get_balance() {
        std::lock_guard<std::mutex> lock(mtx);
        return balance;
    }

private:
    int account_id;
    double balance;
    std::mutex mtx;
};

void transaction(BankAccount &account, double amount, bool is_deposit) {
    if (is_deposit) {
        account.deposit(amount);
    } else {
        account.withdraw(amount);
    }
}

int main() {
    const int num_accounts = 5;
    std::vector<BankAccount> accounts;
    for (int i = 0; i < num_accounts; ++i) {
        accounts.emplace_back(i, 1000.0);
    }

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(transaction, std::ref(accounts[i % num_accounts]), 100.0, i % 2 == 0);
    }

    for (auto &t : threads) {
        t.join();
    }

    for (const auto &account : accounts) {
        std::cout << "Account balance: " << account.get_balance() << std::endl;
    }

    return 0;
}