# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *inputFile;
    char *outputFile;
    int verbose;
} Config;

Config* parse_arguments(int argc, char *argv[]) {
    Config *config = malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        return NULL;
    }
    
    config->inputFile = NULL;
    config->outputFile = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "--input") == 0 && i + 1 < argc) {
            config->inputFile = strdup(argv[++i]);
        } else if (strcmp(argv[i], "--output") == 0 && i + 1 < argc) {
            config->outputFile = strdup(argv[++i]);
        } else if (strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else {
            fprintf(stderr, "Unknown argument: %s\n", argv[i]);
            free(config);
            return NULL;
        }
    }

    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        return EXIT_FAILURE;
    }

    // Initialize application with config
    if (config->verbose) {
        printf("Input File: %s\n", config->inputFile);
        printf("Output File: %s\n", config->outputFile);
    }

    // Clean up
    free(config->inputFile);
    free(config->outputFile);
    free(config);
    
    return EXIT_SUCCESS;
}