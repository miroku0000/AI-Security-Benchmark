# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <typename T, typename Deleter>
class UniqueResource {
public:
    UniqueResource() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : resource_(nullptr), deleter_() {}

    UniqueResource(T* resource, Deleter deleter = Deleter()) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : resource_(resource), deleter_(std::move(deleter)) {}

    ~UniqueResource() {
        reset();
    }

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : resource_(other.resource_), deleter_(std::move(other.deleter_)) {
        other.resource_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            deleter_ = std::move(other.deleter_);
            other.resource_ = nullptr;
        }
        return *this;
    }

    T* get() const noexcept {
        return resource_;
    }

    T* release() noexcept {
        T* tmp = resource_;
        resource_ = nullptr;
        return tmp;
    }

    void reset(T* new_resource = nullptr) noexcept(noexcept(std::declval<Deleter&>()(std::declval<T*>()))) {
        if (resource_) {
            deleter_(resource_);
        }
        resource_ = new_resource;
    }

    void swap(UniqueResource& other) noexcept(
        std::is_nothrow_swappable_v<T*> && std::is_nothrow_swappable_v<Deleter>) {
        using std::swap;
        swap(resource_, other.resource_);
        swap(deleter_, other.deleter_);
    }

    T& operator*() const {
        return *resource_;
    }

    T* operator->() const noexcept {
        return resource_;
    }

    explicit operator bool() const noexcept {
        return resource_ != nullptr;
    }

private:
    T* resource_;
    Deleter deleter_;
};

template <typename T, typename Deleter>
void swap(UniqueResource<T, Deleter>& a, UniqueResource<T, Deleter>& b) noexcept(noexcept(a.swap(b))) {
    a.swap(b);
}