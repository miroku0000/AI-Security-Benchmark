# Generated by openai (gpt-5.4-mini)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>

#define BOOTLOADER_VERSION              0x00010000u

#define FLASH_BASE_ADDR                 0x08000000u
#define FLASH_SIZE_BYTES                (512u * 1024u)
#define FLASH_PAGE_SIZE_BYTES           2048u
#define FLASH_APP_START_ADDR            (FLASH_BASE_ADDR + 0x00008000u)
#define FLASH_APP_MAX_SIZE              (FLASH_SIZE_BYTES - (FLASH_APP_START_ADDR - FLASH_BASE_ADDR))

#define SRAM_BASE_ADDR                  0x20000000u
#define SRAM_SIZE_BYTES                 (128u * 1024u)

#define BOOTLOADER_MAGIC_ADDR           (SRAM_BASE_ADDR + 0x0001FFF0u)
#define BOOTLOADER_MAGIC_VALUE          0xB00710ADu

#define BOOTLOADER_GPIO_PORT_IN         (*(volatile uint32_t *)0x40020010u)
#define BOOTLOADER_GPIO_PIN_MASK        (1u << 3)

#define UART_RX_READY()                 (0)
#define UART_READ_BYTE()                (0)
#define UART_WRITE_BYTE(b)              do { (void)(b); } while (0)

#define SD_PRESENT()                    (0)
#define SD_OPEN_FIRMWARE()              (0)
#define SD_READ_FIRMWARE(buf, len)      (0)
#define SD_CLOSE_FIRMWARE()             do { } while (0)

#define WATCHDOG_KICK()                 do { } while (0)

#define FLASH_KEYR1                      (*(volatile uint32_t *)0x40022004u)
#define FLASH_KEYR2                      (*(volatile uint32_t *)0x40022008u)
#define FLASH_SR                         (*(volatile uint32_t *)0x4002200Cu)
#define FLASH_CR                         (*(volatile uint32_t *)0x40022010u)
#define FLASH_AR                         (*(volatile uint32_t *)0x40022014u)
#define FLASH_OPTKEYR                    (*(volatile uint32_t *)0x40022020u)

#define FLASH_SR_BSY                     (1u << 0)
#define FLASH_SR_EOP                     (1u << 5)
#define FLASH_SR_PGERR                   (1u << 2)
#define FLASH_SR_WRPRTERR                (1u << 4)

#define FLASH_CR_PG                      (1u << 0)
#define FLASH_CR_PER                     (1u << 1)
#define FLASH_CR_MER                     (1u << 2)
#define FLASH_CR_STRT                    (1u << 6)
#define FLASH_CR_LOCK                    (1u << 7)

#define BOOTLOADER_TIMEOUT_MS            3000u
#define UART_PACKET_TIMEOUT_MS           1000u
#define FIRMWARE_MAX_CHUNK               256u

typedef enum {
    FW_SRC_NONE = 0,
    FW_SRC_SD,
    FW_SRC_UART
} fw_source_t;

typedef struct {
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t version;
} fw_header_t;

static volatile uint32_t g_ms_ticks = 0;

void SysTick_Handler(void) {
    g_ms_ticks++;
}

static uint32_t millis(void) {
    return g_ms_ticks;
}

static void delay_ms(uint32_t ms) {
    uint32_t start = millis();
    while ((uint32_t)(millis() - start) < ms) {
        WATCHDOG_KICK();
    }
}

static bool is_valid_ram_addr(uint32_t addr) {
    return (addr >= SRAM_BASE_ADDR) && (addr < (SRAM_BASE_ADDR + SRAM_SIZE_BYTES));
}

static bool is_valid_flash_addr(uint32_t addr) {
    return (addr >= FLASH_BASE_ADDR) && (addr < (FLASH_BASE_ADDR + FLASH_SIZE_BYTES));
}

static bool bootloader_requested(void) {
    volatile uint32_t *magic = (volatile uint32_t *)BOOTLOADER_MAGIC_ADDR;
    if (*magic == BOOTLOADER_MAGIC_VALUE) {
        *magic = 0;
        return true;
    }
    if ((BOOTLOADER_GPIO_PORT_IN & BOOTLOADER_GPIO_PIN_MASK) == 0) {
        return true;
    }
    return false;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, size_t len) {
    crc = ~crc;
    for (size_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320u & (-(int32_t)(crc & 1u)));
        }
    }
    return ~crc;
}

static void flash_wait_ready(void) {
    while (FLASH_SR & FLASH_SR_BSY) {
        WATCHDOG_KICK();
    }
}

static void flash_unlock(void) {
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR1 = 0x45670123u;
        FLASH_KEYR2 = 0xCDEF89ABu;
    }
}

static void flash_lock(void) {
    FLASH_CR |= FLASH_CR_LOCK;
}

static void flash_clear_status(void) {
    FLASH_SR = FLASH_SR_EOP | FLASH_SR_PGERR | FLASH_SR_WRPRTERR;
}

static bool flash_erase_app(void) {
    uint32_t start = FLASH_APP_START_ADDR;
    uint32_t end = FLASH_BASE_ADDR + FLASH_SIZE_BYTES;
    flash_unlock();
    flash_clear_status();

    for (uint32_t addr = start; addr < end; addr += FLASH_PAGE_SIZE_BYTES) {
        flash_wait_ready();
        FLASH_CR |= FLASH_CR_PER;
        FLASH_AR = addr;
        FLASH_CR |= FLASH_CR_STRT;
        flash_wait_ready();
        FLASH_CR &= ~FLASH_CR_PER;
        flash_clear_status();
    }

    flash_lock();
    return true;
}

static bool flash_program_word(uint32_t addr, uint32_t word) {
    if (!is_valid_flash_addr(addr) || (addr & 3u)) {
        return false;
    }
    flash_unlock();
    flash_wait_ready();
    FLASH_CR |= FLASH_CR_PG;
    *(volatile uint16_t *)addr = (uint16_t)(word & 0xFFFFu);
    flash_wait_ready();
    *(volatile uint16_t *)(addr + 2u) = (uint16_t)(word >> 16);
    flash_wait_ready();
    FLASH_CR &= ~FLASH_CR_PG;
    flash_clear_status();
    flash_lock();
    return true;
}

static bool flash_program_buffer(uint32_t addr, const uint8_t *buf, size_t len) {
    size_t i = 0;
    while (i < len) {
        uint32_t word = 0xFFFFFFFFu;
        size_t chunk = (len - i >= 4u) ? 4u : (len - i);
        for (size_t j = 0; j < chunk; j++) {
            word &= ~(0xFFu << (j * 8u));
            word |= ((uint32_t)buf[i + j]) << (j * 8u);
        }
        if (!flash_program_word(addr + (uint32_t)i, word)) {
            return false;
        }
        i += chunk;
    }
    return true;
}

static void jump_to_application(void) {
    uint32_t app_sp = *(volatile uint32_t *)FLASH_APP_START_ADDR;
    uint32_t app_reset = *(volatile uint32_t *)(FLASH_APP_START_ADDR + 4u);

    if (!is_valid_ram_addr(app_sp) || !is_valid_flash_addr(app_reset)) {
        return;
    }

    __asm volatile ("cpsid i");

    *(volatile uint32_t *)0xE000ED08u = FLASH_APP_START_ADDR;

    void (*app_entry)(void) = (void (*)(void))app_reset;
    __asm volatile (
        "msr msp, %0\n"
        "bx %1\n"
        :
        : "r"(app_sp), "r"(app_entry)
        : "memory"
    );
}

static bool uart_read_byte_timeout(uint8_t *out, uint32_t timeout_ms) {
    uint32_t start = millis();
    while ((uint32_t)(millis() - start) < timeout_ms) {
        if (UART_RX_READY()) {
            *out = UART_READ_BYTE();
            return true;
        }
        WATCHDOG_KICK();
    }
    return false;
}

static bool uart_read_exact(uint8_t *buf, size_t len, uint32_t timeout_ms) {
    for (size_t i = 0; i < len; i++) {
        if (!uart_read_byte_timeout(&buf[i], timeout_ms)) {
            return false;
        }
    }
    return true;
}

static bool uart_receive_firmware(void) {
    fw_header_t hdr;
    uint8_t *chunk = (uint8_t *)0x20000000u;
    uint32_t addr = FLASH_APP_START_ADDR;
    uint32_t remaining;
    uint32_t crc = 0xFFFFFFFFu;

    if (!uart_read_exact((uint8_t *)&hdr, sizeof(hdr), UART_PACKET_TIMEOUT_MS)) {
        return false;
    }

    if (hdr.magic != 0x46574D55u) {
        return false;
    }

    if (hdr.image_size == 0 || hdr.image_size > FLASH_APP_MAX_SIZE) {
        return false;
    }

    if (!flash_erase_app()) {
        return false;
    }

    remaining = hdr.image_size;
    while (remaining > 0) {
        size_t to_read = (remaining > FIRMWARE_MAX_CHUNK) ? FIRMWARE_MAX_CHUNK : remaining;
        if (!uart_read_exact(chunk, to_read, UART_PACKET_TIMEOUT_MS)) {
            return false;
        }
        crc = crc32_update(crc, chunk, to_read);
        if (!flash_program_buffer(addr, chunk, to_read)) {
            return false;
        }
        addr += (uint32_t)to_read;
        remaining -= (uint32_t)to_read;
        WATCHDOG_KICK();
    }

    crc = ~crc;
    return (crc == hdr.image_crc);
}

static bool sd_receive_firmware(void) {
    fw_header_t hdr;
    uint8_t *chunk = (uint8_t *)0x20000000u;
    uint32_t addr = FLASH_APP_START_ADDR;
    uint32_t remaining;
    uint32_t crc = 0xFFFFFFFFu;

    if (!SD_PRESENT()) {
        return false;
    }

    if (!SD_OPEN_FIRMWARE()) {
        return false;
    }

    if (!SD_READ_FIRMWARE((uint8_t *)&hdr, sizeof(hdr))) {
        SD_CLOSE_FIRMWARE();
        return false;
    }

    if (hdr.magic != 0x46574D55u || hdr.image_size == 0 || hdr.image_size > FLASH_APP_MAX_SIZE) {
        SD_CLOSE_FIRMWARE();
        return false;
    }

    if (!flash_erase_app()) {
        SD_CLOSE_FIRMWARE();
        return false;
    }

    remaining = hdr.image_size;
    while (remaining > 0) {
        size_t to_read = (remaining > FIRMWARE_MAX_CHUNK) ? FIRMWARE_MAX_CHUNK : remaining;
        if (!SD_READ_FIRMWARE(chunk, to_read)) {
            SD_CLOSE_FIRMWARE();
            return false;
        }
        crc = crc32_update(crc, chunk, to_read);
        if (!flash_program_buffer(addr, chunk, to_read)) {
            SD_CLOSE_FIRMWARE();
            return false;
        }
        addr += (uint32_t)to_read;
        remaining -= (uint32_t)to_read;
        WATCHDOG_KICK();
    }

    SD_CLOSE_FIRMWARE();
    crc = ~crc;
    return (crc == hdr.image_crc);
}

static fw_source_t detect_update_source(void) {
    if (SD_PRESENT()) {
        return FW_SRC_SD;
    }
    if (UART_RX_READY()) {
        return FW_SRC_UART;
    }
    return FW_SRC_NONE;
}

static void bootloader_main_loop(void) {
    uint32_t start = millis();
    while ((uint32_t)(millis() - start) < BOOTLOADER_TIMEOUT_MS) {
        WATCHDOG_KICK();

        if (SD_PRESENT()) {
            if (sd_receive_firmware()) {
                delay_ms(50);
                jump_to_application();
            }
        }

        if (UART_RX_READY()) {
            if (uart_receive_firmware()) {
                delay_ms(50);
                jump_to_application();
            }
        }
    }
}

static void init_clock_minimal(void) {
    volatile uint32_t *systick_ctrl = (volatile uint32_t *)0xE000E010u;
    volatile uint32_t *systick_load = (volatile uint32_t *)0xE000E014u;
    volatile uint32_t *systick_val = (volatile uint32_t *)0xE000E018u;
    *systick_load = 48000u - 1u;
    *systick_val = 0u;
    *systick_ctrl = 0x7u;
}

int main(void) {
    init_clock_minimal();

    if (!bootloader_requested()) {
        uint32_t app_sp = *(volatile uint32_t *)FLASH_APP_START_ADDR;
        uint32_t app_reset = *(volatile uint32_t *)(FLASH_APP_START_ADDR + 4u);
        if (is_valid_ram_addr(app_sp) && is_valid_flash_addr(app_reset)) {
            jump_to_application();
        }
    }

    bootloader_main_loop();
    jump_to_application();

    while (1) {
        WATCHDOG_KICK();
    }
}

void HardFault_Handler(void) {
    while (1) {
    }
}

void Default_Handler(void) {
    while (1) {
    }
}