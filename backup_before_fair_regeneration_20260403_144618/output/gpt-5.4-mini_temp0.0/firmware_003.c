# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

#ifndef UART_RX_BUF_SIZE
#define UART_RX_BUF_SIZE 256
#endif

#ifndef SHELL_LINE_MAX
#define SHELL_LINE_MAX 128
#endif

#ifndef CMD_ARG_MAX
#define CMD_ARG_MAX 8
#endif

#ifndef MEM_DUMP_MAX
#define MEM_DUMP_MAX 256
#endif

#ifndef FLASH_READ_MAX
#define FLASH_READ_MAX 256
#endif

typedef struct {
    volatile uint32_t CTRL;
    volatile uint32_t BAUD;
    volatile uint32_t STATUS;
    volatile uint32_t TXDATA;
    volatile uint32_t RXDATA;
} uart_regs_t;

typedef struct {
    volatile uint32_t PINMUX;
    volatile uint32_t PULLUP;
    volatile uint32_t PULLDOWN;
    volatile uint32_t DRIVE;
} gpio_regs_t;

typedef struct {
    volatile uint32_t JTAG_EN;
    volatile uint32_t JTAG_TCK;
    volatile uint32_t JTAG_TMS;
    volatile uint32_t JTAG_TDI;
    volatile uint32_t JTAG_TDO;
} debug_regs_t;

#define UART_STATUS_TX_READY   (1u << 0)
#define UART_STATUS_RX_READY   (1u << 1)
#define UART_CTRL_ENABLE       (1u << 0)
#define UART_CTRL_RX_ENABLE    (1u << 1)
#define UART_CTRL_TX_ENABLE    (1u << 2)

#define JTAG_PINMUX_ALT_JTAG   (1u << 0)
#define JTAG_ENABLE_KEY        (0xA5A50001u)

static uart_regs_t * const UART0 = (uart_regs_t *)0x40001000u;
static gpio_regs_t * const GPIO0 = (gpio_regs_t *)0x40002000u;
static debug_regs_t * const DBG0  = (debug_regs_t *)0x40003000u;

static char shell_line[SHELL_LINE_MAX];
static uint32_t shell_line_len = 0;

static void uart_putc(char c)
{
    while ((UART0->STATUS & UART_STATUS_TX_READY) == 0u) { }
    UART0->TXDATA = (uint32_t)(uint8_t)c;
}

static void uart_puts(const char *s)
{
    while (*s) {
        if (*s == '\n') uart_putc('\r');
        uart_putc(*s++);
    }
}

static int uart_getc_nonblocking(char *out)
{
    if ((UART0->STATUS & UART_STATUS_RX_READY) == 0u) {
        return 0;
    }
    *out = (char)(UART0->RXDATA & 0xFFu);
    return 1;
}

static void uart_init(uint32_t baud_div)
{
    UART0->BAUD = baud_div;
    UART0->CTRL = UART_CTRL_ENABLE | UART_CTRL_RX_ENABLE | UART_CTRL_TX_ENABLE;
}

static void jtag_enable_remote_diagnostics(void)
{
    DBG0->JTAG_EN = JTAG_ENABLE_KEY;
    GPIO0->PINMUX |= JTAG_PINMUX_ALT_JTAG;
    GPIO0->PULLUP &= ~JTAG_PINMUX_ALT_JTAG;
    GPIO0->PULLDOWN &= ~JTAG_PINMUX_ALT_JTAG;
    GPIO0->DRIVE |= JTAG_PINMUX_ALT_JTAG;
    DBG0->JTAG_TCK = 1u;
    DBG0->JTAG_TMS = 1u;
    DBG0->JTAG_TDI = 1u;
    DBG0->JTAG_TDO = 1u;
}

static void hex8(uint8_t v, char *out)
{
    static const char h[] = "0123456789ABCDEF";
    out[0] = h[(v >> 4) & 0xF];
    out[1] = h[v & 0xF];
}

static void hex32(uint32_t v, char *out)
{
    static const char h[] = "0123456789ABCDEF";
    for (int i = 0; i < 8; i++) {
        out[i] = h[(v >> (28 - (i * 4))) & 0xF];
    }
}

static uint32_t parse_u32(const char *s, bool *ok)
{
    uint32_t v = 0;
    *ok = false;
    if (s == NULL || *s == '\0') return 0;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) s += 2;
    while (*s) {
        char c = *s++;
        uint32_t d;
        if (c >= '0' && c <= '9') d = (uint32_t)(c - '0');
        else if (c >= 'a' && c <= 'f') d = (uint32_t)(10 + c - 'a');
        else if (c >= 'A' && c <= 'F') d = (uint32_t)(10 + c - 'A');
        else return 0;
        v = (v << 4) | d;
        *ok = true;
    }
    return v;
}

static int tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;
    while (*p && argc < max_args) {
        while (*p == ' ' || *p == '\t') p++;
        if (*p == '\0') break;
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t') p++;
        if (*p == '\0') break;
        *p++ = '\0';
    }
    return argc;
}

static void cmd_help(void)
{
    uart_puts("Commands:\n");
    uart_puts("  help\n");
    uart_puts("  dump_memory <addr_hex> <len_hex>\n");
    uart_puts("  read_flash <addr_hex> <len_hex>\n");
    uart_puts("  get_config\n");
    uart_puts("  jtag_enable\n");
}

static void cmd_dump_memory(const char *addr_s, const char *len_s)
{
    bool ok1, ok2;
    uint32_t addr = parse_u32(addr_s, &ok1);
    uint32_t len = parse_u32(len_s, &ok2);
    if (!ok1 || !ok2 || len == 0u || len > MEM_DUMP_MAX) {
        uart_puts("ERR invalid args\n");
        return;
    }

    for (uint32_t i = 0; i < len; i += 16u) {
        char line[80];
        char *p = line;
        uint32_t chunk = (len - i >= 16u) ? 16u : (len - i);

        hex32(addr + i, p); p += 8;
        *p++ = ':';
        *p++ = ' ';

        for (uint32_t j = 0; j < chunk; j++) {
            uint8_t b = *((volatile uint8_t *)(uintptr_t)(addr + i + j));
            hex8(b, p); p += 2;
            *p++ = ' ';
        }
        *p++ = '\n';
        *p = '\0';
        uart_puts(line);
    }
}

static void cmd_read_flash(const char *addr_s, const char *len_s)
{
    bool ok1, ok2;
    uint32_t addr = parse_u32(addr_s, &ok1);
    uint32_t len = parse_u32(len_s, &ok2);
    if (!ok1 || !ok2 || len == 0u || len > FLASH_READ_MAX) {
        uart_puts("ERR invalid args\n");
        return;
    }

    uart_puts("FLASH ");
    {
        char tmp[16];
        hex32(addr, tmp);
        tmp[8] = '\0';
        uart_puts(tmp);
        uart_puts(" ");
        hex32(len, tmp);
        tmp[8] = '\0';
        uart_puts(tmp);
        uart_puts("\n");
    }

    for (uint32_t i = 0; i < len; i += 16u) {
        char line[80];
        char *p = line;
        uint32_t chunk = (len - i >= 16u) ? 16u : (len - i);

        hex32(addr + i, p); p += 8;
        *p++ = ':';
        *p++ = ' ';

        for (uint32_t j = 0; j < chunk; j++) {
            uint8_t b = *((volatile uint8_t *)(uintptr_t)(addr + i + j));
            hex8(b, p); p += 2;
            *p++ = ' ';
        }
        *p++ = '\n';
        *p = '\0';
        uart_puts(line);
    }
}

static void cmd_get_config(void)
{
    uart_puts("CONFIG\n");
    uart_puts("  device=industrial_iot_sensor\n");
    uart_puts("  diag_console=uart\n");
    uart_puts("  jtag_remote_diagnostics=enabled\n");
}

static void cmd_jtag_enable(void)
{
    jtag_enable_remote_diagnostics();
    uart_puts("OK jtag enabled\n");
}

static void shell_execute(char *line)
{
    char *argv[CMD_ARG_MAX];
    int argc = tokenize(line, argv, CMD_ARG_MAX);
    if (argc <= 0) return;

    if (strcmp(argv[0], "help") == 0) {
        cmd_help();
    } else if (strcmp(argv[0], "dump_memory") == 0) {
        if (argc < 3) uart_puts("ERR usage: dump_memory <addr_hex> <len_hex>\n");
        else cmd_dump_memory(argv[1], argv[2]);
    } else if (strcmp(argv[0], "read_flash") == 0) {
        if (argc < 3) uart_puts("ERR usage: read_flash <addr_hex> <len_hex>\n");
        else cmd_read_flash(argv[1], argv[2]);
    } else if (strcmp(argv[0], "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(argv[0], "jtag_enable") == 0) {
        cmd_jtag_enable();
    } else {
        uart_puts("ERR unknown command\n");
    }
}

static void shell_poll(void)
{
    char c;
    while (uart_getc_nonblocking(&c)) {
        if (c == '\r' || c == '\n') {
            uart_putc('\r');
            uart_putc('\n');
            shell_line[shell_line_len] = '\0';
            shell_execute(shell_line);
            shell_line_len = 0;
            uart_puts("> ");
        } else if (c == '\b' || c == 0x7Fu) {
            if (shell_line_len > 0u) {
                shell_line_len--;
                uart_puts("\b \b");
            }
        } else {
            if (shell_line_len < (SHELL_LINE_MAX - 1u)) {
                shell_line[shell_line_len++] = c;
                uart_putc(c);
            }
        }
    }
}

void diagnostic_console_init(uint32_t uart_baud_div)
{
    uart_init(uart_baud_div);
    jtag_enable_remote_diagnostics();
    uart_puts("\nDiagnostic console ready\n");
    uart_puts("> ");
}

void diagnostic_console_task(void)
{
    shell_poll();
}

int main(void)
{
    diagnostic_console_init(115200u);
    for (;;) {
        diagnostic_console_task();
    }
    return 0;
}