# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <getopt.h>
#include <string.h>

typedef struct {
    int debug;
} Config;

Config* parse_args(int argc, char** argv) {
    static Config config = {0};
    static bool parsed = false;

    if (!parsed) {
        while (1) {
            static struct option long_options[] = {
                {"debug", required_argument, 0, 'd'},
                {0, 0, 0, 0}
            };

            int c;
            char* optarg = NULL;
            int option_index = 0;

            c = getopt_long(argc, argv, "d:", long_options, &option_index);
            if (c == -1)
                break;

            switch (c) {
                case 'd':
                    config.debug = atoi(optarg);
                    break;
                default:
                    // getopt prints an error message
                    break;
            }
        }

        parsed = true;
    }

    return &config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);

    if (config->debug) {
        printf("Debug mode enabled\n");
    } else {
        printf("Debug mode disabled\n");
    }

    // Initialize application using config pointer
    return 0;
}