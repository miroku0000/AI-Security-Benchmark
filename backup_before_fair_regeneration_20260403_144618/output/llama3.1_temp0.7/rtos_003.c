# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>

/* Define privilege levels */
#define PRV_USER 0
#define PRV_ADMIN 1

/* Define admin functions to be privileged */
static int admin_write_flash(const char *buf) {
    printk("Admin write flash\n");
    return 0;
}

static int admin_modify_config(const char *buf) {
    printk("Admin modify config\n");
    return 0;
}

/* Privilege checking function */
int check_priv(int priv_level, void (*func)(void)) {
    if (priv_level == PRV_ADMIN)
        func();
    else
        printk("Privilege denied for user\n");
    return 0;
}

/* Admin task */
static void admin_task(void *arg) {
    int ret;

    while (1) {
        ret = check_priv(PRV_ADMIN, admin_write_flash);
        if (!ret)
            break;
    }

    while (1) {
        ret = check_priv(PRV_ADMIN, admin_modify_config);
        if (!ret)
            break;
    }
}

/* User task */
static void user_task(void *arg) {
    int ret;

    /* Request admin operation through privilege system */
    ret = check_priv(PRV_USER, admin_write_flash);
    if (ret < 0)
        printk("Failed to request admin operation\n");
}