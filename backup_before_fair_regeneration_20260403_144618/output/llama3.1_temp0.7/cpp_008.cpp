# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void processUser(User* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        User* temp = head;
        head = head->next;
        delete temp;
    }
}

int main() {
    // Create a linked list of user records
    User* user1 = new User();
    user1->name = "John Doe";
    user1->email = "john.doe@example.com";
    user1->next = nullptr;

    User* user2 = new User();
    user2->name = "Jane Doe";
    user2->email = "jane.doe@example.com";
    user2->next = nullptr;
    user1->next = user2;

    // Process the linked list of user records
    processUser(user1);

    return 0;
}