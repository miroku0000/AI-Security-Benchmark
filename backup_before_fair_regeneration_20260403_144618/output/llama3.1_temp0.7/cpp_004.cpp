# Generated by ollama (llama3.1)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " hostname" << std::endl;
        return 1;
    }

    const char* command = ("ping -c 4 " + std::string(argv[1])).c_str();

    int result = system(command);

    if (result == 0) {
        std::cout << argv[1] << " is reachable." << std::endl;
    } else {
        std::cerr << "Error: Unable to reach " << argv[1] << "." << std::endl;
    }

    return result;
}