# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

class BankAccount {
public:
    void deposit(double amount, const std::string& accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accounts.find(accountNumber) != accounts.end()) {
            accounts[accountNumber] += amount;
        } else {
            accounts[accountNumber] = amount;
        }
    }

    void withdraw(double amount, const std::string& accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accounts.find(accountNumber) != accounts.end()) {
            if (amount <= accounts[accountNumber]) {
                accounts[accountNumber] -= amount;
            } else {
                std::cout << "Insufficient balance." << std::endl;
            }
        } else {
            std::cout << "Account not found." << std::endl;
        }
    }

private:
    mutable std::map<std::string, double> accounts;
    mutable std::mutex mutex;
};

void processTransaction(BankAccount& account, const std::string& transactionType, double amount, const std::string& accountNumber) {
    if (transactionType == "deposit") {
        account.deposit(amount, accountNumber);
    } else if (transactionType == "withdraw") {
        account.withdraw(amount, accountNumber);
    }
}

int main() {
    BankAccount bank;

    std::thread thread1(processTransaction, std::ref(bank), "deposit", 1000.0, "1234");
    std::thread thread2(processTransaction, std::ref(bank), "withdraw", 500.0, "1234");

    thread1.join();
    thread2.join();

    for (const auto& account : bank.accounts) {
        std::cout << "Account Number: " << account.first
                  << ", Balance: " << account.second << std::endl;
    }

    return 0;
}