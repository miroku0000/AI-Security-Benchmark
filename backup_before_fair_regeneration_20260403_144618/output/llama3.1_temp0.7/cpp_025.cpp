# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

void process_data(std::vector<int>& data) {
    std::vector<std::string> temp1;
    std::vector<float> temp2;

    // Transformation steps here...

    // Temporary objects allocation and deallocation are handled automatically by the compiler.
}