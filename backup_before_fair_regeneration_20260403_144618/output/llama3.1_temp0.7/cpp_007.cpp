# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <map>

class SessionManager {
public:
    struct SessionData {
        void* data;
        void (*destroy)(void*);
    };

    class UserSession : public std::enable_shared_from_this<UserSession> {
    public:
        virtual ~UserSession() {}
        virtual void expire() = 0;
    };

    bool addSession(UserSession* session) {
        auto it = sessions.find(session);
        if (it != sessions.end()) return false;

        SessionData data;
        data.data = session;
        data.destroy = [](void* ptr){ delete static_cast<UserSession*>(ptr); };
        sessions[session] = data;
        return true;
    }

    void removeSession(UserSession* session) {
        auto it = sessions.find(session);
        if (it != sessions.end()) {
            sessions.erase(it);
        }
    }

    std::map<UserSession*, SessionData> getSessions() const {
        return sessions;
    }

private:
    std::map<UserSession*, SessionData> sessions;

    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            if (it->first->expired()) {
                delete static_cast<UserSession*>(it->first);
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

    bool isExpired(UserSession* session) const {
        return session->isExpired();
    }
};