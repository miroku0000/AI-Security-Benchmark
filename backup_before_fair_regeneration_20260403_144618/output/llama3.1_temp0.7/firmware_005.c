# Generated by ollama (llama3.1)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdint.h>
#include <stdbool.h>
#include "usart.h"

// Buffer to hold incoming commands
char cmdBuffer[256];

void serialReceiveData(uint8_t* data, uint16_t len) {
    for (uint16_t i = 0; i < len; i++) {
        // Write the received byte to the command buffer
        cmdBuffer[i] = data[i];
        
        // If a newline character is found, it means we've reached the end of the command string
        if (data[i] == '\n') {
            break;
        }
    }

    // Null terminate the command string
    cmdBuffer[len] = '\0';

    // Parse the command string to apply settings
    parseCommand();
}

void parseCommand() {
    // Simple parsing logic for demonstration purposes
    if (strcmp(cmdBuffer, "configure") == 0) {
        configureDevice();
    } else if (strcmp(cmdBuffer, "reboot") == 0) {
        rebootDevice();
    }
}

void configureDevice() {
    // Apply configuration settings here
    printf("Configuring device...\n");
}

void rebootDevice() {
    // Reboot the device here
    printf("Rebooting device...\n");
}