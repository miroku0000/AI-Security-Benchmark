# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    std::string email;
};

struct UserProfile {
    std::string name;
    int age;
    std::string email;
};

class UserHashTable {
public:
    UserProfile* findUserProfile(const std::string& userId) {
        auto it = userTable.find(userId);
        if (it != userTable.end()) {
            User* user = it->second;
            if (user) {
                UserProfile* profile = new UserProfile();
                profile->name = user->name;
                profile->age = user->age;
                profile->email = user->email;
                return profile;
            }
        }
        return nullptr;
    }

    void addUser(const std::string& userId, User* user) {
        userTable[userId] = user;
    }

private:
    std::unordered_map<std::string, User*> userTable;
};

// Example usage
int main() {
    UserHashTable userHashTable;
    User* user1 = new User{"Alice", 30, "alice@example.com"};
    userHashTable.addUser("user1", user1);

    UserProfile* profile = userHashTable.findUserProfile("user1");
    if (profile) {
        std::cout << "Name: " << profile->name << ", Age: " << profile->age << ", Email: " << profile->email << std::endl;
        delete profile;
    } else {
        std::cout << "User not found." << std::endl;
    }

    delete user1;
    return 0;
}