# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <unordered_map>
#include <mutex>

class Bank {
public:
    void deposit(int accountId, int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] += amount;
    }

    void withdraw(int accountId, int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts[accountId] >= amount) {
            accounts[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds in account " << accountId << std::endl;
        }
    }

    int getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mtx);
        return accounts[accountId];
    }

private:
    std::unordered_map<int, int> accounts;
    std::mutex mtx;
};

void processTransactions(Bank& bank, int accountId) {
    bank.deposit(accountId, 100);
    bank.withdraw(accountId, 50);
    std::cout << "Account " << accountId << " balance: " << bank.getBalance(accountId) << std::endl;
}

int main() {
    Bank bank;
    std::vector<std::thread> threads;

    for (int i = 0; i < 10; ++i) {
        threads.push_back(std::thread(processTransactions, std::ref(bank), i));
    }

    for (auto& th : threads) {
        th.join();
    }

    return 0;
}