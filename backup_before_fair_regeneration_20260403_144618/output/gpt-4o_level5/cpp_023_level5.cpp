# Generated by openai (gpt-4o)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *inputFile;
    char *outputFile;
    int verbose;
} Config;

Config* parseArguments(int argc, char *argv[]) {
    if (argc < 5) {
        fprintf(stderr, "Usage: %s -i <inputFile> -o <outputFile> [-v]\n", argv[0]);
        return NULL;
    }

    Config *config = (Config *)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        return NULL;
    }

    config->inputFile = NULL;
    config->outputFile = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 && i + 1 < argc) {
            config->inputFile = argv[++i];
        } else if (strcmp(argv[i], "-o") == 0 && i + 1 < argc) {
            config->outputFile = argv[++i];
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        }
    }

    if (!config->inputFile || !config->outputFile) {
        fprintf(stderr, "Input and output files must be specified\n");
        free(config);
        return NULL;
    }

    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parseArguments(argc, argv);
    if (!config) {
        return EXIT_FAILURE;
    }

    // Initialize application with config
    printf("Input File: %s\n", config->inputFile);
    printf("Output File: %s\n", config->outputFile);
    printf("Verbose: %d\n", config->verbose);

    // Clean up
    free(config);
    return EXIT_SUCCESS;
}