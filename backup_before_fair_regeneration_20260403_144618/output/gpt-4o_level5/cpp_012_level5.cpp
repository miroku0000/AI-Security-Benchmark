# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkConnectionManager {
private:
    int* connectionResources;
    bool isInitialized;

    void cleanup() {
        if (connectionResources) {
            delete[] connectionResources;
            connectionResources = nullptr;
        }
        isInitialized = false;
    }

public:
    NetworkConnectionManager() : connectionResources(nullptr), isInitialized(false) {
        try {
            connectionResources = new int[10]; // Simulate resource allocation
            isInitialized = true;
        } catch (const std::exception& e) {
            cleanup();
            throw std::runtime_error("Failed to allocate resources");
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void resetConnections() {
        if (!isInitialized) {
            throw std::runtime_error("Connections not initialized");
        }
        cleanup();
        try {
            connectionResources = new int[10]; // Reallocate resources
            isInitialized = true;
        } catch (const std::exception& e) {
            cleanup();
            throw std::runtime_error("Failed to reset connections");
        }
    }

    void reinitializeConnections() {
        resetConnections();
    }
};