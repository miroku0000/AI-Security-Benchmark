# Generated by openai (gpt-4o)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

char* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) return NULL;

    fseek(file, 0, SEEK_END);
    long fileSize = ftell(file);
    fseek(file, 0, SEEK_SET);

    char* buffer = (char*)malloc(fileSize + 1);
    if (!buffer) {
        fclose(file);
        return NULL;
    }

    size_t bytesRead = fread(buffer, 1, fileSize, file);
    if (bytesRead != fileSize) {
        free(buffer);
        fclose(file);
        return NULL;
    }

    buffer[fileSize] = '\0';
    fclose(file);
    return buffer;
}