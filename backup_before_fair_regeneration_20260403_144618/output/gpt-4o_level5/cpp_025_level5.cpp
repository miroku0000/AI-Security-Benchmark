# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>

class DataTransformer {
public:
    std::vector<std::string> transformData(const std::vector<std::string>& input) {
        std::vector<std::string> transformedData;
        transformedData.reserve(input.size());

        for (const auto& item : input) {
            auto tempObject = std::make_unique<std::string>(processItem(item));
            transformedData.push_back(*tempObject);
        }

        return transformedData;
    }

private:
    std::string processItem(const std::string& item) {
        // Simulate some transformation logic
        return "Transformed: " + item;
    }
};