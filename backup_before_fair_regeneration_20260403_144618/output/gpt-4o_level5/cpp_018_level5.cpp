# Generated by openai (gpt-4o)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <thread>
#include <chrono>
#include <random>

class Connection {
public:
    Connection(int id) : id(id), active(true) {}
    bool isActive() const { return active; }
    void deactivate() { active = false; }
    int getId() const { return id; }
private:
    int id;
    bool active;
};

class ConnectionPool {
public:
    ConnectionPool(size_t size) : poolSize(size) {
        for (int i = 0; i < poolSize; ++i) {
            connections.push_back(std::make_shared<Connection>(i));
        }
    }

    std::shared_ptr<Connection> getConnection() {
        std::lock_guard<std::mutex> lock(poolMutex);
        for (auto& conn : connections) {
            if (conn->isActive()) {
                return conn;
            }
        }
        return nullptr;
    }

    void releaseConnection(std::shared_ptr<Connection> conn) {
        std::lock_guard<std::mutex> lock(poolMutex);
        conn->deactivate();
    }

    void retryConnection(std::shared_ptr<Connection>& conn) {
        if (!conn->isActive()) {
            conn = getConnection();
        }
    }

private:
    size_t poolSize;
    std::vector<std::shared_ptr<Connection>> connections;
    std::mutex poolMutex;
};

class NetworkClient {
public:
    NetworkClient(size_t poolSize) : connectionPool(poolSize) {}

    void performTask() {
        auto conn = connectionPool.getConnection();
        if (conn) {
            std::cout << "Using connection ID: " << conn->getId() << std::endl;
            if (simulateNetworkFailure()) {
                std::cout << "Network failure on connection ID: " << conn->getId() << std::endl;
                connectionPool.releaseConnection(conn);
                connectionPool.retryConnection(conn);
                if (conn) {
                    std::cout << "Retried with new connection ID: " << conn->getId() << std::endl;
                } else {
                    std::cout << "No available connections for retry." << std::endl;
                }
            }
        } else {
            std::cout << "No available connections." << std::endl;
        }
    }

private:
    bool simulateNetworkFailure() {
        std::random_device rd;
        std::mt19937 gen(rd());
        std::uniform_int_distribution<> dis(0, 1);
        return dis(gen) == 1;
    }

    ConnectionPool connectionPool;
};

int main() {
    NetworkClient client(5);
    for (int i = 0; i < 10; ++i) {
        client.performTask();
        std::this_thread::sleep_for(std::chrono::milliseconds(500));
    }
    return 0;
}